v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/gnd.sym} 4320 8100 0 0 {name="l_gnd_24_0" lab="GND"}
C {sky130_fd_pr/nfet3_01v8.sym} 9840 5860 0 0 {name="M_nmos_10_1"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9820 4620 0 0 {name="M_nmos_11_2"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6160 7400 0 1 {name="M_nmos_12_3"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5680 4040 0 0 {name="M_nmos_13_4"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4860 7400 0 0 {name="M_nmos_14_5"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2960 4060 0 1 {name="M_nmos_17_6"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8720 4600 0 1 {name="M_nmos_18_7"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7080 7400 0 0 {name="M_nmos_4_8"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2480 7320 0 0 {name="M_nmos_5_9"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8740 5860 0 1 {name="M_nmos_6_10"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3740 7400 0 1 {name="M_nmos_8_11"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1320 7380 0 1 {name="M_nmos_9_12"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 4060 0 0 {name="M_nmos_cross_0_13"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5060 4100 0 1 {name="M_nmos_cross_1_14"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2880 2000 0 0 {name="M_pmos_15_15"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9820 3000 0 0 {name="M_pmos_16_16"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8720 3020 0 1 {name="M_pmos_19_17"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8700 1800 0 1 {name="M_pmos_20_18"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5320 2000 0 1 {name="M_pmos_21_19"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4060 780 0 0 {name="M_pmos_22_20"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9840 1800 0 0 {name="M_pmos_7_21"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1040 2000 0 1 {name="M_pmos_cross_2_22"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7320 2020 0 0 {name="M_pmos_cross_3_23"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 9280 4400 0 0 {name="p_port_25_24" lab="PORT_refined_12"}
C {devices/ipin.sym} 9280 5600 0 0 {name="p_port_26_25" lab="PORT_refined_14"}
C {devices/ipin.sym} 10800 3860 0 0 {name="p_port_27_26" lab="PORT_refined_16"}
C {devices/ipin.sym} 360 2020 0 0 {name="p_port_28_27" lab="PORT_refined_18"}
C {devices/ipin.sym} 3580 800 0 0 {name="p_port_29_28" lab="PORT_refined_23"}
C {devices/ipin.sym} 7880 1500 0 0 {name="p_port_30_29" lab="PORT_refined_22"}
C {devices/ipin.sym} 4280 7080 0 0 {name="p_port_31_30" lab="PORT_refined_6"}
C {devices/ipin.sym} 4280 3700 0 0 {name="p_port_40_31" lab="PORT_refined_4"}
T {Vb2} 4310 3660 0 0 0.25 0.25 {}
C {devices/ipin.sym} 9280 2760 0 0 {name="p_port_41_32" lab="PORT_refined_20"}
T {Vb6} 9310 2720 0 0 0.25 0.25 {}
C {devices/vdd.sym} 9260 920 0 0 {name="l_vdd_23_33" lab="VDD"}
N 6140 7940 7290 7940 {}
N 1160 7930 2680 7930 {}
N 2760 7930 3470 7930 {}
N 3550 7930 4320 7930 {}
N 4320 7930 5090 7930 {}
N 5090 7930 5870 7930 {}
N 5950 7930 6140 7930 {}
N 1070 7920 1160 7920 {}
N 2680 7920 2720 7920 {}
N 2720 7920 2760 7920 {}
N 3470 7920 3510 7920 {}
N 3510 7920 3550 7920 {}
N 5870 7920 5910 7920 {}
N 5910 7920 5950 7920 {}
N 1060 7910 1070 7910 {}
N 7290 7890 7300 7890 {}
N 2710 7870 2720 7870 {}
N 4880 7730 5090 7730 {}
N 7100 7730 7300 7730 {}
N 2500 7660 2710 7660 {}
N 3510 7430 3720 7430 {}
N 5910 7430 6140 7430 {}
N 1060 7410 1300 7410 {}
N 1060 7910 1060 7410 {}
N 1070 7920 1070 7910 {}
N 1160 7930 1160 7920 {}
N 2500 7660 2500 7350 {}
N 2680 7930 2680 7920 {}
N 2710 7870 2710 7660 {}
N 2720 7920 2720 7870 {}
N 2760 7930 2760 7920 {}
N 3470 7930 3470 7920 {}
N 3510 7920 3510 7430 {}
N 3550 7930 3550 7920 {}
N 4320 8100 4320 7930 {}
N 4880 7730 4880 7430 {}
N 5090 7930 5090 7730 {}
N 5870 7930 5870 7920 {}
N 5910 7920 5910 7430 {}
N 5950 7930 5950 7920 {}
N 6140 7940 6140 7930 {}
N 7100 7730 7100 7430 {}
N 7290 7940 7290 7890 {}
N 7300 7890 7300 7730 {}
N 9860 5520 10080 5520 {}
N 9840 4950 10080 4950 {}
N 9840 4950 9840 4650 {}
N 9860 5830 9860 5520 {}
N 10080 5520 10080 4950 {}
N 7100 7060 7300 7060 {}
N 7300 6900 10080 6900 {}
N 9860 6200 10080 6200 {}
N 7300 2050 7340 2050 {}
N 7100 7370 7100 7060 {}
N 7300 7060 7300 6900 {}
N 7300 6900 7300 2050 {}
N 9860 6200 9860 5890 {}
N 10080 6900 10080 6200 {}
N 8470 4570 8700 4570 {}
N 8470 3640 9160 3640 {}
N 8470 3050 8700 3050 {}
N 8720 1820 9160 1820 {}
N 9160 1820 9540 1820 {}
N 9540 1800 9820 1800 {}
N 8470 4570 8470 3640 {}
N 8470 3640 8470 3050 {}
N 8720 1820 8720 1800 {}
N 9160 3640 9160 1820 {}
N 9540 1820 9540 1800 {}
N 9540 4620 9800 4620 {}
N 9320 4610 9540 4610 {}
N 8740 4600 9220 4600 {}
N 9270 4600 9320 4600 {}
N 9220 4590 9260 4590 {}
N 9260 4590 9270 4590 {}
N 9260 4540 9270 4540 {}
N 9270 4400 9280 4400 {}
N 9220 4600 9220 4590 {}
N 9260 4590 9260 4540 {}
N 9270 4600 9270 4590 {}
N 9270 4540 9270 4400 {}
N 9320 4610 9320 4600 {}
N 9540 4620 9540 4610 {}
N 1060 7350 1300 7350 {}
N 1040 6520 1060 6520 {}
N 1060 6510 1070 6510 {}
N 1070 6500 8500 6500 {}
N 1060 6480 1070 6480 {}
N 8500 5890 8720 5890 {}
N 1060 2630 1070 2630 {}
N 1020 2340 1070 2340 {}
N 1020 2340 1020 2030 {}
N 1060 7350 1060 6520 {}
N 1060 6520 1060 6510 {}
N 1060 6480 1060 2630 {}
N 1070 6510 1070 6500 {}
N 1070 6500 1070 6480 {}
N 1070 2630 1070 2340 {}
N 8500 6500 8500 5890 {}
N 8760 5890 9230 5890 {}
N 9310 5890 9560 5890 {}
N 9230 5880 9270 5880 {}
N 9270 5880 9310 5880 {}
N 9560 5860 9820 5860 {}
N 9270 5600 9280 5600 {}
N 8760 5890 8760 5860 {}
N 9230 5890 9230 5880 {}
N 9270 5880 9270 5600 {}
N 9270 5600 9270 5590 {}
N 9310 5890 9310 5880 {}
N 9560 5890 9560 5860 {}
N 3510 7370 3720 7370 {}
N 3510 4090 3560 4090 {}
N 3510 7370 3510 4090 {}
N 9840 4270 10060 4270 {}
N 10060 3920 10070 3920 {}
N 10070 3900 10080 3900 {}
N 10080 3870 10090 3870 {}
N 10090 3870 10140 3870 {}
N 10140 3860 10800 3860 {}
N 10080 3830 10090 3830 {}
N 10070 3820 10080 3820 {}
N 10060 3810 10070 3810 {}
N 9840 3330 10060 3330 {}
N 9840 4590 9840 4270 {}
N 9840 3330 9840 3030 {}
N 10060 4270 10060 3920 {}
N 10060 3810 10060 3330 {}
N 10070 3920 10070 3900 {}
N 10070 3820 10070 3810 {}
N 10080 3900 10080 3870 {}
N 10080 3830 10080 3820 {}
N 10090 3870 10090 3830 {}
N 10140 3870 10140 3860 {}
N 7280 1990 7340 1990 {}
N 5090 1970 5300 1970 {}
N 1020 1660 1070 1660 {}
N 2900 1650 3110 1650 {}
N 1070 1450 1080 1450 {}
N 7270 1450 7280 1450 {}
N 1080 1440 1570 1440 {}
N 3070 1440 3110 1440 {}
N 3110 1440 3150 1440 {}
N 1570 1430 3070 1430 {}
N 3150 1430 3700 1430 {}
N 3700 1420 4300 1420 {}
N 4300 1420 5090 1420 {}
N 5090 1420 5820 1420 {}
N 5820 1410 7270 1410 {}
N 4080 1100 4300 1100 {}
N 1020 1970 1020 1660 {}
N 1070 1660 1070 1450 {}
N 1080 1450 1080 1440 {}
N 1570 1440 1570 1430 {}
N 2900 1970 2900 1650 {}
N 3070 1440 3070 1430 {}
N 3110 1650 3110 1440 {}
N 3150 1440 3150 1430 {}
N 3700 1430 3700 1420 {}
N 4080 1100 4080 810 {}
N 4300 1420 4300 1100 {}
N 5090 1970 5090 1420 {}
N 5820 1420 5820 1410 {}
N 7270 1450 7270 1410 {}
N 7280 1990 7280 1450 {}
N 360 2020 540 2020 {}
N 1060 2020 2590 2020 {}
N 540 2000 1060 2000 {}
N 2590 2000 2860 2000 {}
N 540 2020 540 2000 {}
N 1060 2020 1060 2000 {}
N 2590 2020 2590 2000 {}
N 9840 2670 10060 2670 {}
N 9860 2120 10060 2120 {}
N 9840 2970 9840 2670 {}
N 9860 2120 9860 1830 {}
N 10060 2670 10060 2120 {}
N 6790 7400 7060 7400 {}
N 6180 7310 6510 7310 {}
N 6510 7310 6790 7310 {}
N 5040 3750 5090 3750 {}
N 5700 3700 5910 3700 {}
N 5890 3300 5910 3300 {}
N 5910 3270 5950 3270 {}
N 5900 3260 5910 3260 {}
N 5950 3260 5970 3260 {}
N 5890 3250 5900 3250 {}
N 5970 3250 6510 3250 {}
N 5090 3240 5110 3240 {}
N 5880 3240 5890 3240 {}
N 5070 3230 5090 3230 {}
N 5110 3230 5880 3230 {}
N 5050 3220 5070 3220 {}
N 5000 3210 5050 3210 {}
N 4970 3200 5000 3200 {}
N 4940 3190 4970 3190 {}
N 4900 3180 4940 3180 {}
N 4870 3170 4900 3170 {}
N 4840 3160 4870 3160 {}
N 4800 3150 4840 3150 {}
N 4770 3140 4800 3140 {}
N 4740 3130 4770 3130 {}
N 4710 3120 4740 3120 {}
N 4670 3110 4710 3110 {}
N 4640 3100 4670 3100 {}
N 4610 3090 4640 3090 {}
N 4580 3080 4610 3080 {}
N 4540 3070 4580 3070 {}
N 4510 3060 4540 3060 {}
N 4480 3050 4510 3050 {}
N 4440 3040 4480 3040 {}
N 4360 3030 4440 3030 {}
N 4180 2960 4360 2960 {}
N 4150 2950 4180 2950 {}
N 4120 2940 4150 2940 {}
N 4080 2930 4120 2930 {}
N 4050 2920 4080 2920 {}
N 4020 2910 4050 2910 {}
N 3990 2900 4020 2900 {}
N 3950 2890 3990 2890 {}
N 3920 2880 3950 2880 {}
N 3890 2870 3920 2870 {}
N 3860 2860 3890 2860 {}
N 3820 2850 3860 2850 {}
N 3790 2840 3820 2840 {}
N 3760 2830 3790 2830 {}
N 3720 2820 3760 2820 {}
N 3700 2810 3720 2810 {}
N 3660 2800 3700 2800 {}
N 3630 2790 3660 2790 {}
N 3590 2780 3630 2780 {}
N 3560 2770 3590 2770 {}
N 3530 2760 3560 2760 {}
N 3500 2750 3530 2750 {}
N 3460 2740 3500 2740 {}
N 3430 2730 3460 2730 {}
N 3400 2720 3430 2720 {}
N 3370 2710 3400 2710 {}
N 3340 2700 3370 2700 {}
N 3300 2690 3340 2690 {}
N 3270 2680 3300 2680 {}
N 3230 2670 3270 2670 {}
N 3200 2660 3230 2660 {}
N 3170 2650 3200 2650 {}
N 3140 2640 3170 2640 {}
N 3120 2630 3140 2630 {}
N 3110 2620 3120 2620 {}
N 2900 2320 3110 2320 {}
N 2900 2320 2900 2030 {}
N 3110 2620 3110 2320 {}
N 3120 2630 3120 2620 {}
N 3140 2640 3140 2630 {}
N 3170 2650 3170 2640 {}
N 3200 2660 3200 2650 {}
N 3230 2670 3230 2660 {}
N 3270 2680 3270 2670 {}
N 3300 2690 3300 2680 {}
N 3340 2700 3340 2690 {}
N 3370 2710 3370 2700 {}
N 3400 2720 3400 2710 {}
N 3430 2730 3430 2720 {}
N 3460 2740 3460 2730 {}
N 3500 2750 3500 2740 {}
N 3530 2760 3530 2750 {}
N 3560 2770 3560 2760 {}
N 3590 2780 3590 2770 {}
N 3630 2790 3630 2780 {}
N 3660 2800 3660 2790 {}
N 3700 2810 3700 2800 {}
N 3720 2820 3720 2810 {}
N 3760 2830 3760 2820 {}
N 3790 2840 3790 2830 {}
N 3820 2850 3820 2840 {}
N 3860 2860 3860 2850 {}
N 3890 2870 3890 2860 {}
N 3920 2880 3920 2870 {}
N 3950 2890 3950 2880 {}
N 3990 2900 3990 2890 {}
N 4020 2910 4020 2900 {}
N 4050 2920 4050 2910 {}
N 4080 2930 4080 2920 {}
N 4120 2940 4120 2930 {}
N 4150 2950 4150 2940 {}
N 4180 2960 4180 2950 {}
N 4360 3030 4360 2960 {}
N 4440 3040 4440 3030 {}
N 4480 3050 4480 3040 {}
N 4510 3060 4510 3050 {}
N 4540 3070 4540 3060 {}
N 4580 3080 4580 3070 {}
N 4610 3090 4610 3080 {}
N 4640 3100 4640 3090 {}
N 4670 3110 4670 3100 {}
N 4710 3120 4710 3110 {}
N 4740 3130 4740 3120 {}
N 4770 3140 4770 3130 {}
N 4800 3150 4800 3140 {}
N 4840 3160 4840 3150 {}
N 4870 3170 4870 3160 {}
N 4900 3180 4900 3170 {}
N 4940 3190 4940 3180 {}
N 4970 3200 4970 3190 {}
N 5000 3210 5000 3200 {}
N 5040 4070 5040 3750 {}
N 5050 3220 5050 3210 {}
N 5070 3230 5070 3220 {}
N 5090 3750 5090 3240 {}
N 5090 3240 5090 3230 {}
N 5110 3240 5110 3230 {}
N 5700 4010 5700 3700 {}
N 5880 3240 5880 3230 {}
N 5890 3250 5890 3240 {}
N 5900 3260 5900 3250 {}
N 5910 3700 5910 3300 {}
N 5910 3300 5910 3270 {}
N 5910 3270 5910 3260 {}
N 5950 3270 5950 3260 {}
N 5970 3260 5970 3250 {}
N 6180 7400 6180 7310 {}
N 6510 7310 6510 3250 {}
N 6790 7400 6790 7310 {}
N 8740 3030 9310 3030 {}
N 9310 3030 9540 3030 {}
N 9270 3020 9310 3020 {}
N 9540 3000 9800 3000 {}
N 9270 2780 9300 2780 {}
N 9280 2760 9300 2760 {}
N 9300 2760 9310 2760 {}
N 9270 2680 9280 2680 {}
N 8740 3030 8740 3020 {}
N 9270 3020 9270 2780 {}
N 9270 2780 9270 2680 {}
N 9280 2680 9280 2660 {}
N 9300 2780 9300 2760 {}
N 9310 3030 9310 3020 {}
N 9540 3030 9540 3000 {}
N 8470 2990 8700 2990 {}
N 8460 2460 8470 2460 {}
N 8280 2420 8460 2420 {}
N 8270 2410 8280 2410 {}
N 8460 2410 8470 2410 {}
N 8470 1830 8680 1830 {}
N 4080 440 4300 440 {}
N 4300 220 4310 220 {}
N 4310 210 4320 210 {}
N 4320 200 8270 200 {}
N 4080 750 4080 440 {}
N 4300 440 4300 220 {}
N 4310 220 4310 210 {}
N 4320 210 4320 200 {}
N 8270 2410 8270 200 {}
N 8280 2420 8280 2410 {}
N 8460 2460 8460 2420 {}
N 8460 2420 8460 2410 {}
N 8470 2990 8470 2460 {}
N 8470 2410 8470 1830 {}
N 5340 2020 7300 2020 {}
N 7300 2020 7880 2020 {}
N 5340 2020 5340 2000 {}
N 7880 2020 7880 1500 {}
N 3580 800 3770 800 {}
N 3770 780 4040 780 {}
N 3770 800 3770 780 {}
N 8470 1770 8680 1770 {}
N 9860 1450 10060 1450 {}
N 8470 1210 9270 1210 {}
N 9270 1210 10060 1210 {}
N 9260 920 9270 920 {}
N 8470 1770 8470 1210 {}
N 9270 1210 9270 920 {}
N 9860 1770 9860 1450 {}
N 10060 1450 10060 1210 {}
N 5910 7370 6140 7370 {}
N 5700 4380 5910 4380 {}
N 5700 4380 5700 4070 {}
N 5910 7370 5910 4380 {}
N 4570 4100 5080 4100 {}
N 3450 4060 3520 4060 {}
N 2980 4050 3450 4050 {}
N 3520 4050 4230 4050 {}
N 4310 4050 4570 4050 {}
N 5080 4050 5390 4050 {}
N 4230 4040 4270 4040 {}
N 4270 4040 4310 4040 {}
N 5390 4040 5660 4040 {}
N 4270 3720 4300 3720 {}
N 4280 3700 4300 3700 {}
N 4300 3700 4310 3700 {}
N 2980 4060 2980 4050 {}
N 3450 4060 3450 4050 {}
N 3520 4060 3520 4050 {}
N 4230 4050 4230 4040 {}
N 4270 4040 4270 3720 {}
N 4300 3720 4300 3700 {}
N 4310 4050 4310 4040 {}
N 4570 4100 4570 4050 {}
N 5080 4100 5080 4050 {}
N 5390 4050 5390 4040 {}
N 4880 7060 5090 7060 {}
N 5040 4430 5090 4430 {}
N 4880 7370 4880 7060 {}
N 5040 4430 5040 4130 {}
N 5090 7060 5090 4430 {}
N 4580 7400 4840 7400 {}
N 3760 7380 4250 7380 {}
N 4320 7380 4580 7380 {}
N 4250 7370 4290 7370 {}
N 4290 7370 4320 7370 {}
N 4280 7210 4290 7210 {}
N 3760 7400 3760 7380 {}
N 4250 7380 4250 7370 {}
N 4280 7210 4280 7080 {}
N 4290 7370 4290 7210 {}
N 4320 7380 4320 7370 {}
N 4580 7400 4580 7380 {}
N 2500 6980 2710 6980 {}
N 2710 4090 2940 4090 {}
N 2500 7290 2500 6980 {}
N 2710 6980 2710 4090 {}
N 2190 7320 2460 7320 {}
N 1340 7310 1920 7310 {}
N 1920 7310 2190 7310 {}
N 1910 7270 1920 7270 {}
N 2710 4030 2940 4030 {}
N 3510 4030 3560 4030 {}
N 1910 3450 1920 3450 {}
N 1920 3440 2710 3440 {}
N 2710 3440 3510 3440 {}
N 3510 3440 3530 3440 {}
N 3530 3430 3550 3430 {}
N 3550 3420 3560 3420 {}
N 3560 3410 3580 3410 {}
N 3580 3400 3600 3400 {}
N 3600 3390 3620 3390 {}
N 3620 3380 3640 3380 {}
N 3640 3370 3660 3370 {}
N 3660 3360 3680 3360 {}
N 3680 3350 3700 3350 {}
N 3700 3340 3720 3340 {}
N 3720 3330 3740 3330 {}
N 3740 3320 3760 3320 {}
N 3760 3310 3780 3310 {}
N 3780 3300 3800 3300 {}
N 3800 3290 3820 3290 {}
N 3820 3280 3840 3280 {}
N 3840 3270 3860 3270 {}
N 3860 3260 3880 3260 {}
N 3880 3250 3900 3250 {}
N 3900 3240 3920 3240 {}
N 3920 3230 3940 3230 {}
N 3940 3220 3960 3220 {}
N 3960 3210 3980 3210 {}
N 3980 3200 3990 3200 {}
N 3990 3190 4010 3190 {}
N 4010 3180 4030 3180 {}
N 4030 3170 4050 3170 {}
N 4050 3160 4070 3160 {}
N 4070 3150 4090 3150 {}
N 4090 3140 4110 3140 {}
N 4110 3130 4130 3130 {}
N 4130 3120 4150 3120 {}
N 4150 3110 4170 3110 {}
N 4170 3100 4190 3100 {}
N 4190 3090 4260 3090 {}
N 4260 2970 4440 2970 {}
N 4440 2960 4460 2960 {}
N 4460 2950 4480 2950 {}
N 4480 2940 4500 2940 {}
N 4500 2930 4520 2930 {}
N 4520 2920 4540 2920 {}
N 4540 2910 4560 2910 {}
N 4560 2900 4580 2900 {}
N 4580 2890 4600 2890 {}
N 4600 2880 4620 2880 {}
N 4620 2870 4640 2870 {}
N 4640 2860 4660 2860 {}
N 4660 2850 4680 2850 {}
N 4680 2840 4700 2840 {}
N 4700 2830 4720 2830 {}
N 4720 2820 4740 2820 {}
N 4740 2810 4760 2810 {}
N 4760 2800 4770 2800 {}
N 4770 2790 4790 2790 {}
N 4790 2780 4810 2780 {}
N 4810 2770 4830 2770 {}
N 4830 2760 4850 2760 {}
N 4850 2750 4870 2750 {}
N 4870 2740 4890 2740 {}
N 4890 2730 4910 2730 {}
N 4910 2720 4930 2720 {}
N 4930 2710 4950 2710 {}
N 4950 2700 4970 2700 {}
N 4970 2690 4990 2690 {}
N 4990 2680 5010 2680 {}
N 5010 2670 5030 2670 {}
N 5030 2660 5050 2660 {}
N 5050 2650 5070 2650 {}
N 5070 2640 5090 2640 {}
N 5090 2030 5300 2030 {}
N 1340 7380 1340 7310 {}
N 1910 7270 1910 3450 {}
N 1920 7310 1920 7270 {}
N 1920 3450 1920 3440 {}
N 2190 7320 2190 7310 {}
N 2710 4030 2710 3440 {}
N 3510 4030 3510 3440 {}
N 3530 3440 3530 3430 {}
N 3550 3430 3550 3420 {}
N 3560 3420 3560 3410 {}
N 3580 3410 3580 3400 {}
N 3600 3400 3600 3390 {}
N 3620 3390 3620 3380 {}
N 3640 3380 3640 3370 {}
N 3660 3370 3660 3360 {}
N 3680 3360 3680 3350 {}
N 3700 3350 3700 3340 {}
N 3720 3340 3720 3330 {}
N 3740 3330 3740 3320 {}
N 3760 3320 3760 3310 {}
N 3780 3310 3780 3300 {}
N 3800 3300 3800 3290 {}
N 3820 3290 3820 3280 {}
N 3840 3280 3840 3270 {}
N 3860 3270 3860 3260 {}
N 3880 3260 3880 3250 {}
N 3900 3250 3900 3240 {}
N 3920 3240 3920 3230 {}
N 3940 3230 3940 3220 {}
N 3960 3220 3960 3210 {}
N 3980 3210 3980 3200 {}
N 3990 3200 3990 3190 {}
N 4010 3190 4010 3180 {}
N 4030 3180 4030 3170 {}
N 4050 3170 4050 3160 {}
N 4070 3160 4070 3150 {}
N 4090 3150 4090 3140 {}
N 4110 3140 4110 3130 {}
N 4130 3130 4130 3120 {}
N 4150 3120 4150 3110 {}
N 4170 3110 4170 3100 {}
N 4190 3100 4190 3090 {}
N 4260 3090 4260 2970 {}
N 4440 2970 4440 2960 {}
N 4460 2960 4460 2950 {}
N 4480 2950 4480 2940 {}
N 4500 2940 4500 2930 {}
N 4520 2930 4520 2920 {}
N 4540 2920 4540 2910 {}
N 4560 2910 4560 2900 {}
N 4580 2900 4580 2890 {}
N 4600 2890 4600 2880 {}
N 4620 2880 4620 2870 {}
N 4640 2870 4640 2860 {}
N 4660 2860 4660 2850 {}
N 4680 2850 4680 2840 {}
N 4700 2840 4700 2830 {}
N 4720 2830 4720 2820 {}
N 4740 2820 4740 2810 {}
N 4760 2810 4760 2800 {}
N 4770 2800 4770 2790 {}
N 4790 2790 4790 2780 {}
N 4810 2780 4810 2770 {}
N 4830 2770 4830 2760 {}
N 4850 2760 4850 2750 {}
N 4870 2750 4870 2740 {}
N 4890 2740 4890 2730 {}
N 4910 2730 4910 2720 {}
N 4930 2720 4930 2710 {}
N 4950 2710 4950 2700 {}
N 4970 2700 4970 2690 {}
N 4990 2690 4990 2680 {}
N 5010 2680 5010 2670 {}
N 5030 2670 5030 2660 {}
N 5050 2660 5050 2650 {}
N 5070 2650 5070 2640 {}
N 5090 2640 5090 2030 {}
N 8500 5830 8720 5830 {}
N 8500 4630 8700 4630 {}
N 8500 5830 8500 4630 {}
