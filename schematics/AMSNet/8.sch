v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 220 340 0 0 {name="I_current_0_0" value=1m}
C {devices/ipin.sym} 220 580 0 0 {name="p_port_1_1" lab="PORT_reconstructed_1"}
C {devices/vdd.sym} 220 120 0 0 {name="l_vdd_2_2" lab="VDD"}
N 220 310 220 120 {}
N 220 580 220 370 {}
