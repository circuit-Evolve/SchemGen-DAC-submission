v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 300 420 0 0 {name="I_current_0_0" value=1m}
C {devices/gnd.sym} 300 560 0 0 {name="l_gnd_1_1" lab="GND"}
C {devices/ipin.sym} 300 120 0 0 {name="p_port_3_2" lab="PORT_reconstructed_0"}
N 300 390 300 120 {}
N 300 560 300 450 {}
