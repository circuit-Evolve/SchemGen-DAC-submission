v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_1.sym} 880 1840 3 0 {name="C_capacitor_16_0" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 720 2640 1 0 {name="C_capacitor_18_1" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 880 2080 3 0 {name="C_capacitor_19_2" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3960 1480 3 0 {name="C_capacitor_22_3" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3500 2640 1 0 {name="C_capacitor_24_4" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3960 1300 3 0 {name="C_capacitor_34_5" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2700 480 2 0 {name="C_capacitor_38_6" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1480 480 2 0 {name="C_capacitor_40_7" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {devices/gnd.sym} 320 3240 0 0 {name="l_gnd_23_8" lab="GND"}
C {devices/gnd.sym} 3800 2300 0 0 {name="l_gnd_26_9" lab="GND"}
C {devices/gnd.sym} 3060 3240 0 0 {name="l_gnd_30_10" lab="GND"}
C {devices/gnd.sym} 3500 2300 0 0 {name="l_gnd_31_11" lab="GND"}
C {devices/gnd.sym} 360 2320 0 0 {name="l_gnd_32_12" lab="GND"}
C {devices/gnd.sym} 1660 3240 0 0 {name="l_gnd_33_13" lab="GND"}
C {devices/gnd.sym} 2520 3240 0 0 {name="l_gnd_36_14" lab="GND"}
C {devices/gnd.sym} 1100 3240 0 0 {name="l_gnd_39_15" lab="GND"}
C {devices/ind.sym} 1260 460 2 0 {name="L_inductor_37_16"
m=1
value=1n
footprint=1206
device=inductor}
C {devices/ind.sym} 2920 460 2 0 {name="L_inductor_41_17"
m=1
value=1n
footprint=1206
device=inductor}
C {sky130_fd_pr/nfet_01v8.sym} 1140 2880 0 1 {name="M_nmos_bulk_10_18"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2740 1780 0 1 {name="M_nmos_bulk_11_19"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1940 1800 0 1 {name="M_nmos_bulk_14_20"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3020 2880 0 0 {name="M_nmos_bulk_15_21"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2560 2880 0 1 {name="M_nmos_bulk_17_22"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3780 1800 0 0 {name="M_nmos_bulk_20_23"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1620 2880 0 0 {name="M_nmos_bulk_21_24"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1440 1800 0 0 {name="M_nmos_bulk_25_25"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3460 1800 0 0 {name="M_nmos_bulk_27_26"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3760 1160 0 0 {name="M_nmos_bulk_28_27"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2200 1780 0 0 {name="M_nmos_bulk_29_28"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3460 1060 0 0 {name="M_nmos_bulk_35_29"
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1700 880 0 1 {name="M_pmos_bulk_12_30"
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3100 2580 0 1 {name="M_pmos_bulk_13_31"
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2480 880 0 0 {name="M_pmos_bulk_7_32"
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1080 2580 0 0 {name="M_pmos_bulk_9_33"
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 2100 800 0 0 {name="p_port_42_34" lab="PORT_refined_18"}
C {devices/ipin.sym} 3040 1480 0 0 {name="p_port_43_35" lab="PORT_refined_7"}
C {devices/ipin.sym} 1020 1460 0 0 {name="p_port_44_36" lab="PORT_refined_9"}
C {devices/ipin.sym} 600 2300 0 0 {name="p_port_45_37" lab="PORT_refined_4"}
C {devices/ipin.sym} 4240 1480 0 0 {name="p_port_69_38" lab="PORT_refined_20"}
C {devices/ipin.sym} 4500 1300 0 0 {name="p_port_8_39" lab="PORT_refined_19"}
C {sky130_fd_pr/res_generic_po.sym} 3260 1680 2 0 {name="R_resistor2_0_40"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 2100 2720 1 0 {name="R_resistor2_1_41"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 3320 2480 2 0 {name="R_resistor2_2_42"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 840 2480 2 0 {name="R_resistor2_3_43"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 3600 1660 2 0 {name="R_resistor2_4_44"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 2060 1660 2 0 {name="R_resistor2_5_45"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 1140 1680 2 0 {name="R_resistor2_6_46"
W=1
L=1
model=res_generic_po
spiceprefix=X
mult=1}
C {devices/vdd.sym} 3040 2240 0 0 {name="l_vdd_54_47" lab="VDD"}
C {devices/vdd.sym} 2520 200 0 0 {name="l_vdd_62_48" lab="VDD"}
C {devices/vdd.sym} 1120 2260 0 0 {name="l_vdd_68_49" lab="VDD"}
C {devices/vsource.sym} 360 1960 0 0 {name="V_voltage_70_50" value=3 savecurrent=false}
C {devices/vsource.sym} 320 2880 0 0 {name="V_voltage_76_51" value=3 savecurrent=false}
N 1140 2010 2910 2010 {}
N 910 1850 1140 1850 {}
N 1140 1850 1240 1850 {}
N 1260 1850 1280 1850 {}
N 2900 1850 2910 1850 {}
N 1240 1840 1260 1840 {}
N 1280 1840 1380 1840 {}
N 2760 1840 2900 1840 {}
N 1380 1800 1420 1800 {}
N 910 1850 910 1840 {}
N 1140 2010 1140 1850 {}
N 1140 1850 1140 1710 {}
N 1240 1850 1240 1840 {}
N 1260 1850 1260 1840 {}
N 1280 1850 1280 1840 {}
N 1380 1840 1380 1800 {}
N 2760 1840 2760 1780 {}
N 2900 1850 2900 1840 {}
N 2910 2010 2910 1850 {}
N 570 2100 580 2100 {}
N 560 2090 570 2090 {}
N 580 2090 590 2090 {}
N 540 2080 560 2080 {}
N 560 2080 570 2080 {}
N 590 2080 850 2080 {}
N 530 2070 540 2070 {}
N 570 2070 590 2070 {}
N 510 2060 530 2060 {}
N 500 2050 510 2050 {}
N 490 2040 500 2040 {}
N 480 2030 490 2030 {}
N 470 2000 480 2000 {}
N 470 1930 480 1930 {}
N 360 1920 370 1920 {}
N 480 1900 490 1900 {}
N 490 1890 500 1890 {}
N 500 1880 510 1880 {}
N 510 1870 520 1870 {}
N 520 1860 540 1860 {}
N 570 1860 590 1860 {}
N 370 1850 540 1850 {}
N 540 1850 560 1850 {}
N 560 1850 570 1850 {}
N 590 1850 840 1850 {}
N 560 1840 570 1840 {}
N 580 1840 590 1840 {}
N 840 1840 850 1840 {}
N 570 1830 580 1830 {}
N 360 1930 360 1920 {}
N 370 1920 370 1850 {}
N 470 2000 470 1930 {}
N 480 2030 480 2000 {}
N 480 1930 480 1900 {}
N 490 2040 490 2030 {}
N 490 1900 490 1890 {}
N 500 2050 500 2040 {}
N 500 1890 500 1880 {}
N 510 2060 510 2050 {}
N 510 1880 510 1870 {}
N 520 1870 520 1860 {}
N 530 2070 530 2060 {}
N 540 2080 540 2070 {}
N 540 1860 540 1850 {}
N 560 2090 560 2080 {}
N 560 1850 560 1840 {}
N 570 2100 570 2090 {}
N 570 2080 570 2070 {}
N 570 1860 570 1850 {}
N 570 1840 570 1830 {}
N 580 2100 580 2090 {}
N 580 1840 580 1830 {}
N 590 2090 590 2080 {}
N 590 2080 590 2070 {}
N 590 1860 590 1850 {}
N 590 1850 590 1840 {}
N 840 1850 840 1840 {}
N 910 2080 2060 2080 {}
N 1960 1840 2060 1840 {}
N 2060 1840 2150 1840 {}
N 2150 1780 2180 1780 {}
N 1960 1840 1960 1800 {}
N 2060 2080 2060 1840 {}
N 2060 1840 2060 1690 {}
N 2150 1840 2150 1780 {}
N 1100 2590 1180 2590 {}
N 2960 2590 3050 2590 {}
N 1180 2580 1190 2580 {}
N 3050 2580 3080 2580 {}
N 3060 2550 3080 2550 {}
N 1100 2500 1110 2500 {}
N 1110 2440 1190 2440 {}
N 2960 2420 3060 2420 {}
N 1110 2260 1120 2260 {}
N 3040 2240 3060 2240 {}
N 3780 1080 3800 1080 {}
N 3480 980 3500 980 {}
N 1580 890 1640 890 {}
N 2500 890 2590 890 {}
N 1640 880 1680 880 {}
N 1660 850 1680 850 {}
N 2500 810 2520 810 {}
N 1580 740 1660 740 {}
N 2520 740 2590 740 {}
N 1240 430 1260 430 {}
N 2920 340 2940 340 {}
N 1240 260 1480 260 {}
N 1480 260 1660 260 {}
N 1660 260 2520 260 {}
N 2520 260 2700 260 {}
N 2700 260 2940 260 {}
N 2940 260 3500 260 {}
N 3500 260 3800 260 {}
N 1100 2590 1100 2580 {}
N 1100 2550 1100 2500 {}
N 1110 2500 1110 2440 {}
N 1110 2440 1110 2260 {}
N 1180 2590 1180 2580 {}
N 1190 2580 1190 2440 {}
N 1240 430 1240 260 {}
N 1480 450 1480 260 {}
N 1580 890 1580 740 {}
N 1640 890 1640 880 {}
N 1660 850 1660 740 {}
N 1660 740 1660 260 {}
N 2500 890 2500 880 {}
N 2500 850 2500 810 {}
N 2520 810 2520 740 {}
N 2520 740 2520 260 {}
N 2520 260 2520 200 {}
N 2590 890 2590 740 {}
N 2700 450 2700 260 {}
N 2920 430 2920 340 {}
N 2940 340 2940 260 {}
N 2960 2590 2960 2420 {}
N 3050 2590 3050 2580 {}
N 3060 2550 3060 2420 {}
N 3060 2420 3060 2240 {}
N 3480 1030 3480 980 {}
N 3500 980 3500 260 {}
N 3780 1130 3780 1080 {}
N 3800 1080 3800 260 {}
N 500 3280 3600 3280 {}
N 310 2850 320 2850 {}
N 410 2760 420 2760 {}
N 420 2760 500 2760 {}
N 390 2750 410 2750 {}
N 410 2750 420 2750 {}
N 380 2740 390 2740 {}
N 370 2730 380 2730 {}
N 360 2720 370 2720 {}
N 360 2670 370 2670 {}
N 370 2660 380 2660 {}
N 380 2650 390 2650 {}
N 310 2640 390 2640 {}
N 390 2640 420 2640 {}
N 420 2640 690 2640 {}
N 3530 2640 3600 2640 {}
N 310 2850 310 2640 {}
N 360 2720 360 2670 {}
N 370 2730 370 2720 {}
N 370 2670 370 2660 {}
N 380 2740 380 2730 {}
N 380 2660 380 2650 {}
N 390 2750 390 2740 {}
N 390 2650 390 2640 {}
N 410 2760 410 2750 {}
N 420 2760 420 2750 {}
N 420 2650 420 2640 {}
N 500 3280 500 2760 {}
N 3600 3280 3600 2640 {}
N 1900 1770 1920 1770 {}
N 2710 1750 2720 1750 {}
N 2700 1580 2710 1580 {}
N 1900 1220 2700 1220 {}
N 2700 1220 3710 1220 {}
N 3710 1160 3740 1160 {}
N 2700 640 2940 640 {}
N 2920 600 2940 600 {}
N 1900 1770 1900 1220 {}
N 2700 1580 2700 1220 {}
N 2700 1220 2700 640 {}
N 2700 640 2700 510 {}
N 2710 1750 2710 1580 {}
N 2920 600 2920 490 {}
N 2940 640 2940 600 {}
N 3710 1220 3710 1160 {}
N 1460 1710 1480 1710 {}
N 2220 1710 2240 1710 {}
N 1480 1120 2240 1120 {}
N 2240 1120 3410 1120 {}
N 3410 1060 3440 1060 {}
N 1240 650 1480 650 {}
N 1240 490 1260 490 {}
N 1240 650 1240 490 {}
N 1460 1770 1460 1710 {}
N 1480 1710 1480 1120 {}
N 1480 1120 1480 650 {}
N 1480 650 1480 510 {}
N 2220 1750 2220 1710 {}
N 2240 1710 2240 1120 {}
N 3410 1120 3410 1060 {}
N 1160 2940 1320 2940 {}
N 1320 2940 1570 2940 {}
N 1570 2880 1600 2880 {}
N 1110 2850 1120 2850 {}
N 1110 2740 1320 2740 {}
N 1100 2660 1110 2660 {}
N 1100 2660 1100 2610 {}
N 1110 2850 1110 2740 {}
N 1110 2740 1110 2660 {}
N 1160 2940 1160 2880 {}
N 1320 2940 1320 2740 {}
N 1570 2940 1570 2880 {}
N 2580 2940 2840 2940 {}
N 2840 2940 2970 2940 {}
N 2970 2880 3000 2880 {}
N 3040 2810 3060 2810 {}
N 2840 2750 2850 2750 {}
N 2850 2740 3060 2740 {}
N 3060 2610 3080 2610 {}
N 2580 2940 2580 2880 {}
N 2840 2940 2840 2750 {}
N 2850 2750 2850 2740 {}
N 2970 2940 2970 2880 {}
N 3040 2850 3040 2810 {}
N 3060 2810 3060 2740 {}
N 3060 2740 3060 2610 {}
N 3300 1850 3310 1850 {}
N 3270 1840 3280 1840 {}
N 3280 1840 3300 1840 {}
N 3310 1840 3420 1840 {}
N 3260 1800 3270 1800 {}
N 3420 1800 3440 1800 {}
N 3260 1800 3260 1710 {}
N 3270 1840 3270 1800 {}
N 3280 1850 3280 1840 {}
N 3300 1850 3300 1840 {}
N 3310 1850 3310 1840 {}
N 3420 1840 3420 1800 {}
N 1720 940 2100 940 {}
N 2100 940 2420 940 {}
N 2420 880 2460 880 {}
N 1720 940 1720 880 {}
N 2100 940 2100 800 {}
N 2420 940 2420 880 {}
N 4020 1320 4520 1320 {}
N 3990 1300 4020 1300 {}
N 4500 1300 4520 1300 {}
N 4520 1300 4530 1300 {}
N 4020 1320 4020 1300 {}
N 4520 1320 4520 1300 {}
N 1640 2810 1660 2810 {}
N 1660 2730 1980 2730 {}
N 1980 2720 2070 2720 {}
N 1480 1930 1660 1930 {}
N 1660 1930 1900 1930 {}
N 1460 1870 1480 1870 {}
N 1900 1830 1920 1830 {}
N 1660 910 1680 910 {}
N 1460 1870 1460 1830 {}
N 1480 1930 1480 1870 {}
N 1640 2850 1640 2810 {}
N 1660 2810 1660 2730 {}
N 1660 2730 1660 1930 {}
N 1660 1930 1660 910 {}
N 1900 1930 1900 1830 {}
N 1980 2730 1980 2720 {}
N 4020 1500 4260 1500 {}
N 3990 1480 4020 1480 {}
N 4240 1480 4260 1480 {}
N 4260 1480 4270 1480 {}
N 4020 1500 4020 1480 {}
N 4260 1500 4260 1480 {}
N 3480 1730 3610 1730 {}
N 3610 1710 3620 1710 {}
N 3610 1610 3620 1610 {}
N 3480 1470 3610 1470 {}
N 3480 1300 3930 1300 {}
N 3480 1770 3480 1730 {}
N 3480 1470 3480 1300 {}
N 3480 1300 3480 1090 {}
N 3610 1730 3610 1710 {}
N 3610 1610 3610 1470 {}
N 3620 1710 3620 1610 {}
N 3800 1480 3900 1480 {}
N 3900 1480 3930 1480 {}
N 3900 1330 4530 1330 {}
N 4530 1310 4540 1310 {}
N 4520 1290 4540 1290 {}
N 3780 1280 4520 1280 {}
N 3780 1280 3780 1190 {}
N 3800 1770 3800 1480 {}
N 3900 1480 3900 1330 {}
N 4520 1290 4520 1280 {}
N 4530 1330 4530 1310 {}
N 4540 1310 4540 1290 {}
N 3600 1800 3760 1800 {}
N 3600 1800 3600 1690 {}
N 2520 2850 2540 2850 {}
N 2130 2730 2520 2730 {}
N 2220 1840 2520 1840 {}
N 2520 1840 2720 1840 {}
N 2500 960 2520 960 {}
N 2130 2730 2130 2720 {}
N 2220 1840 2220 1810 {}
N 2500 960 2500 910 {}
N 2520 2850 2520 2730 {}
N 2520 2730 2520 1840 {}
N 2520 1840 2520 960 {}
N 2720 1840 2720 1810 {}
N 840 2350 850 2350 {}
N 600 2310 850 2310 {}
N 850 2310 3320 2310 {}
N 600 2310 600 2300 {}
N 840 2450 840 2350 {}
N 850 2350 850 2310 {}
N 3320 2450 3320 2310 {}
N 3120 2640 3320 2640 {}
N 3320 2640 3470 2640 {}
N 3120 2640 3120 2580 {}
N 3320 2640 3320 2510 {}
N 740 2640 750 2640 {}
N 750 2640 850 2640 {}
N 850 2640 1020 2640 {}
N 840 2600 850 2600 {}
N 1020 2580 1060 2580 {}
N 840 2600 840 2510 {}
N 850 2640 850 2600 {}
N 1020 2640 1020 2580 {}
N 3260 1540 3270 1540 {}
N 3040 1480 3270 1480 {}
N 3270 1480 3600 1480 {}
N 3260 1650 3260 1540 {}
N 3270 1540 3270 1480 {}
N 3600 1630 3600 1480 {}
N 1640 3210 1660 3210 {}
N 3040 3210 3060 3210 {}
N 1100 2940 1120 2940 {}
N 2520 2940 2540 2940 {}
N 1640 2930 1660 2930 {}
N 3040 2930 3060 2930 {}
N 1090 2880 1100 2880 {}
N 1100 2880 1120 2880 {}
N 1640 2880 1660 2880 {}
N 1660 2880 1670 2880 {}
N 2510 2880 2520 2880 {}
N 2520 2880 2540 2880 {}
N 3040 2880 3060 2880 {}
N 3060 2880 3070 2880 {}
N 1730 1900 1750 1900 {}
N 1750 1900 1770 1900 {}
N 1770 1880 1780 1880 {}
N 3270 1860 3480 1860 {}
N 1890 1850 2160 1850 {}
N 2920 1850 3270 1850 {}
N 3480 1850 3510 1850 {}
N 3510 1850 3800 1850 {}
N 3800 1850 3820 1850 {}
N 2160 1830 2240 1830 {}
N 2780 1830 2920 1830 {}
N 1460 1800 1750 1800 {}
N 1750 1800 1890 1800 {}
N 1890 1800 1920 1800 {}
N 3480 1800 3510 1800 {}
N 3800 1800 3820 1800 {}
N 3820 1800 3830 1800 {}
N 2220 1780 2240 1780 {}
N 2240 1780 2700 1780 {}
N 2700 1780 2720 1780 {}
N 2700 1730 2780 1730 {}
N 3830 1510 4270 1510 {}
N 4270 1490 4280 1490 {}
N 4280 1340 4540 1340 {}
N 4540 1320 4550 1320 {}
N 4530 1280 4550 1280 {}
N 3800 1270 4530 1270 {}
N 3780 1160 3800 1160 {}
N 3800 1160 3810 1160 {}
N 3510 1110 3800 1110 {}
N 3480 1060 3510 1060 {}
N 320 3240 320 2910 {}
N 360 2320 360 1990 {}
N 1100 3240 1100 2940 {}
N 1100 2940 1100 2880 {}
N 1120 2940 1120 2910 {}
N 1640 3210 1640 2930 {}
N 1640 2930 1640 2910 {}
N 1660 3240 1660 3210 {}
N 1660 2930 1660 2880 {}
N 1750 1900 1750 1800 {}
N 1770 1900 1770 1880 {}
N 1780 1880 1780 1870 {}
N 1890 1850 1890 1800 {}
N 2160 1850 2160 1830 {}
N 2240 1830 2240 1780 {}
N 2520 3240 2520 2940 {}
N 2520 2940 2520 2880 {}
N 2540 2940 2540 2910 {}
N 2700 1780 2700 1730 {}
N 2780 1830 2780 1730 {}
N 2920 1850 2920 1830 {}
N 3040 3210 3040 2930 {}
N 3040 2930 3040 2910 {}
N 3060 3240 3060 3210 {}
N 3060 2930 3060 2880 {}
N 3270 1860 3270 1850 {}
N 3480 1860 3480 1850 {}
N 3480 1850 3480 1830 {}
N 3500 2300 3500 2270 {}
N 3510 1850 3510 1800 {}
N 3510 1110 3510 1060 {}
N 3800 2300 3800 1850 {}
N 3800 1850 3800 1830 {}
N 3800 1270 3800 1160 {}
N 3800 1160 3800 1110 {}
N 3820 1850 3820 1800 {}
N 3830 1800 3830 1510 {}
N 4270 1510 4270 1490 {}
N 4280 1490 4280 1340 {}
N 4530 1280 4530 1270 {}
N 4540 1340 4540 1320 {}
N 4550 1320 4550 1280 {}
N 1020 1460 1140 1460 {}
N 1140 1460 2060 1460 {}
N 1140 1650 1140 1460 {}
N 2060 1630 2060 1460 {}
