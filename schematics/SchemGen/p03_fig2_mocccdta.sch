v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 4860 1640 0 0 {name="I_current_25_0" value=1m}
C {devices/isource.sym} 220 1460 0 0 {name="I_current_27_1" value=1m}
C {devices/gnd.sym} 4380 1280 0 0 {name="l_gnd_35_2" lab="GND"}
C {devices/gnd.sym} 1040 1500 0 0 {name="l_gnd_36_3" lab="GND"}
C {devices/gnd.sym} 500 1520 0 0 {name="l_gnd_37_4" lab="GND"}
C {sky130_fd_pr/nfet3_01v8.sym} 5200 960 0 1 {name="M_nmos_10_5"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1080 1940 0 0 {name="M_nmos_11_6"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1280 900 0 1 {name="M_nmos_13_7"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4540 960 0 0 {name="M_nmos_14_8"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 1940 0 1 {name="M_nmos_15_9"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 320 1940 0 1 {name="M_nmos_17_10"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1740 1940 0 1 {name="M_nmos_21_11"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3220 1940 0 0 {name="M_nmos_23_12"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4120 1940 0 0 {name="M_nmos_6_13"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2420 900 0 0 {name="M_nmos_7_14"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2040 1940 0 0 {name="M_nmos_8_15"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2600 1940 0 1 {name="M_nmos_9_16"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2980 1940 0 1 {name="M_nmos_cross_0_17"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3940 1940 0 1 {name="M_nmos_cross_1_18"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2120 900 0 1 {name="M_nmos_cross_2_19"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1640 900 0 1 {name="M_nmos_cross_3_20"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 700 1940 0 1 {name="M_nmos_cross_4_21"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4120 420 0 0 {name="M_pmos_18_22"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3220 400 0 0 {name="M_pmos_19_23"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2040 400 0 0 {name="M_pmos_20_24"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2420 1460 0 0 {name="M_pmos_24_25"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 420 0 1 {name="M_pmos_26_26"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2600 400 0 1 {name="M_pmos_28_27"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5020 400 0 0 {name="M_pmos_29_28"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1740 420 0 1 {name="M_pmos_30_29"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1260 1460 0 1 {name="M_pmos_31_30"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1080 400 0 0 {name="M_pmos_32_31"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 800 400 0 1 {name="M_pmos_33_32"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4720 400 0 1 {name="M_pmos_34_33"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3940 420 0 1 {name="M_pmos_cross_12_34"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2980 420 0 1 {name="M_pmos_cross_16_35"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1640 1460 0 1 {name="M_pmos_cross_22_36"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2120 1460 0 1 {name="M_pmos_cross_5_37"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 3800 1160 0 0 {name="p_port_38_38" lab="PORT_refined_7"}
C {devices/ipin.sym} 5320 660 0 0 {name="p_port_39_39" lab="PORT_refined_8"}
C {devices/ipin.sym} 2820 1200 0 0 {name="p_port_40_40" lab="PORT_refined_9"}
C {devices/ipin.sym} 5320 2200 0 0 {name="p_port_41_41" lab="PORT_refined_1"}
C {devices/ipin.sym} 5340 160 0 0 {name="p_port_42_42" lab="PORT_refined_10"}
C {devices/ipin.sym} 1520 1180 0 0 {name="p_port_43_43" lab="PORT_refined_3"}
C {devices/ipin.sym} 4100 1140 0 0 {name="p_port_44_44" lab="PORT_refined_11"}
C {devices/ipin.sym} 1960 1180 0 0 {name="p_port_45_45" lab="PORT_refined_5"}
N 4860 1490 4870 1490 {}
N 4870 1490 4880 1490 {}
N 4630 1210 4870 1210 {}
N 4870 1210 5110 1210 {}
N 4560 1170 4630 1170 {}
N 5110 990 5180 990 {}
N 4560 1170 4560 990 {}
N 4630 1210 4630 1170 {}
N 4860 1610 4860 1490 {}
N 4870 1490 4870 1210 {}
N 5110 1210 5110 990 {}
N 1650 2210 1660 2210 {}
N 230 2200 700 2200 {}
N 700 2200 1180 2200 {}
N 1180 2200 1650 2200 {}
N 1650 2200 1660 2200 {}
N 1660 2200 2130 2200 {}
N 2130 2200 2510 2200 {}
N 2510 2200 2980 2200 {}
N 2980 2200 3320 2200 {}
N 3320 2200 3460 2200 {}
N 3460 2200 3940 2200 {}
N 3940 2200 4220 2200 {}
N 4220 2200 4860 2200 {}
N 4870 2200 5320 2200 {}
N 4860 2190 4870 2190 {}
N 680 2150 700 2150 {}
N 1100 2140 1180 2140 {}
N 2060 2140 2130 2140 {}
N 2960 2140 2980 2140 {}
N 3240 2140 3320 2140 {}
N 3920 2140 3940 2140 {}
N 4140 2140 4220 2140 {}
N 230 1970 300 1970 {}
N 1650 1970 1720 1970 {}
N 2510 1970 2580 1970 {}
N 3460 1970 3520 1970 {}
N 4860 1770 4870 1770 {}
N 230 2200 230 1970 {}
N 680 2150 680 1970 {}
N 700 2210 700 2200 {}
N 700 2200 700 2150 {}
N 1100 2140 1100 1970 {}
N 1180 2210 1180 2200 {}
N 1180 2200 1180 2140 {}
N 1650 2200 1650 1970 {}
N 1660 2210 1660 2200 {}
N 2060 2140 2060 1970 {}
N 2130 2200 2130 2140 {}
N 2510 2200 2510 1970 {}
N 2960 2140 2960 1970 {}
N 2980 2200 2980 2140 {}
N 3240 2140 3240 1970 {}
N 3320 2210 3320 2200 {}
N 3320 2200 3320 2140 {}
N 3460 2210 3460 2200 {}
N 3460 2200 3460 1970 {}
N 3920 2140 3920 1970 {}
N 3940 2200 3940 2140 {}
N 4140 2140 4140 1970 {}
N 4220 2200 4220 2140 {}
N 4860 2200 4860 2190 {}
N 4860 1770 4860 1670 {}
N 4870 2200 4870 2190 {}
N 4870 2190 4870 1770 {}
N 1650 390 1720 390 {}
N 3460 390 3520 390 {}
N 700 370 780 370 {}
N 2510 370 2580 370 {}
N 4630 370 4700 370 {}
N 4140 210 4220 210 {}
N 1100 200 1180 200 {}
N 2060 200 2130 200 {}
N 2960 200 2980 200 {}
N 3240 200 3320 200 {}
N 3920 200 3940 200 {}
N 5040 200 5110 200 {}
N 700 180 710 180 {}
N 3310 180 3320 180 {}
N 710 170 1180 170 {}
N 1180 170 1650 170 {}
N 1650 170 2130 170 {}
N 2130 170 2510 170 {}
N 2510 170 2980 170 {}
N 2980 170 3320 170 {}
N 3320 170 3460 170 {}
N 3460 170 3940 170 {}
N 3940 170 4220 170 {}
N 4220 170 4630 170 {}
N 4630 170 5110 170 {}
N 5110 170 5330 170 {}
N 5330 160 5340 160 {}
N 700 370 700 180 {}
N 710 180 710 170 {}
N 1100 370 1100 200 {}
N 1180 200 1180 170 {}
N 1180 170 1180 150 {}
N 1650 390 1650 170 {}
N 2060 370 2060 200 {}
N 2130 200 2130 170 {}
N 2130 170 2130 160 {}
N 2510 370 2510 170 {}
N 2510 170 2510 160 {}
N 2960 390 2960 200 {}
N 2980 200 2980 170 {}
N 3240 370 3240 200 {}
N 3320 200 3320 180 {}
N 3320 180 3320 170 {}
N 3460 390 3460 170 {}
N 3920 390 3920 200 {}
N 3940 200 3940 170 {}
N 4140 390 4140 210 {}
N 4220 210 4220 170 {}
N 4630 370 4630 170 {}
N 4630 170 4630 160 {}
N 5040 370 5040 200 {}
N 5110 200 5110 170 {}
N 5330 170 5330 160 {}
N 4140 1740 4220 1740 {}
N 4100 1150 4220 1150 {}
N 4140 610 4220 610 {}
N 4100 1150 4100 1140 {}
N 4140 1910 4140 1740 {}
N 4140 610 4140 450 {}
N 4220 1740 4220 1150 {}
N 4220 1150 4220 610 {}
N 340 1950 460 1950 {}
N 460 1950 510 1950 {}
N 720 1950 980 1950 {}
N 510 1940 720 1940 {}
N 980 1940 1060 1940 {}
N 460 1930 470 1930 {}
N 230 1910 300 1910 {}
N 460 1710 470 1710 {}
N 230 1700 460 1700 {}
N 220 1590 230 1590 {}
N 220 1590 220 1490 {}
N 230 1910 230 1700 {}
N 230 1700 230 1590 {}
N 340 1950 340 1940 {}
N 460 1960 460 1950 {}
N 460 1950 460 1930 {}
N 460 1710 460 1700 {}
N 470 1930 470 1710 {}
N 510 1950 510 1940 {}
N 720 1950 720 1940 {}
N 980 1950 980 1940 {}
N 1180 1430 1240 1430 {}
N 220 1320 230 1320 {}
N 4380 1280 4390 1280 {}
N 230 1210 240 1210 {}
N 240 1200 500 1200 {}
N 1040 1180 1180 1180 {}
N 4390 970 4400 970 {}
N 4400 960 4520 960 {}
N 1180 930 1260 930 {}
N 220 1430 220 1320 {}
N 230 1320 230 1210 {}
N 240 1210 240 1200 {}
N 500 1520 500 1200 {}
N 1040 1500 1040 1180 {}
N 1180 1430 1180 1180 {}
N 1180 1180 1180 930 {}
N 4390 1280 4390 970 {}
N 4400 970 4400 960 {}
N 1300 910 1420 910 {}
N 1420 910 1460 910 {}
N 1660 910 1930 910 {}
N 2140 910 2310 910 {}
N 1460 900 1660 900 {}
N 1930 900 2140 900 {}
N 2310 900 2400 900 {}
N 1180 870 1260 870 {}
N 1410 870 1420 870 {}
N 1180 660 1410 660 {}
N 1100 610 1180 610 {}
N 1100 610 1100 430 {}
N 1180 870 1180 660 {}
N 1180 660 1180 610 {}
N 1300 910 1300 900 {}
N 1410 870 1410 660 {}
N 1420 920 1420 910 {}
N 1420 910 1420 870 {}
N 1460 910 1460 900 {}
N 1660 910 1660 900 {}
N 1930 910 1930 900 {}
N 2140 910 2140 900 {}
N 2310 910 2310 900 {}
N 4560 760 4630 760 {}
N 4660 730 4860 730 {}
N 4630 720 4660 720 {}
N 4860 720 4870 720 {}
N 4630 430 4700 430 {}
N 4740 420 4870 420 {}
N 4870 420 4910 420 {}
N 4910 400 5000 400 {}
N 4560 930 4560 760 {}
N 4630 760 4630 720 {}
N 4630 720 4630 430 {}
N 4660 730 4660 720 {}
N 4740 420 4740 400 {}
N 4860 730 4860 720 {}
N 4870 720 4870 420 {}
N 4870 420 4870 400 {}
N 4910 420 4910 400 {}
N 3560 1950 3700 1950 {}
N 3700 1950 3740 1950 {}
N 3960 1950 4020 1950 {}
N 3740 1940 3960 1940 {}
N 4020 1940 4100 1940 {}
N 3450 1910 3520 1910 {}
N 3690 1910 3700 1910 {}
N 3440 1690 3450 1690 {}
N 3440 1680 3690 1680 {}
N 3430 1590 3440 1590 {}
N 3420 1500 3430 1500 {}
N 3410 1410 3420 1410 {}
N 3400 1320 3410 1320 {}
N 3390 1270 3400 1270 {}
N 3380 1090 3390 1090 {}
N 3370 1050 3380 1050 {}
N 3360 960 3370 960 {}
N 3350 870 3360 870 {}
N 3340 770 3350 770 {}
N 3330 690 3340 690 {}
N 3240 610 3330 610 {}
N 3240 610 3240 430 {}
N 3330 690 3330 610 {}
N 3340 770 3340 690 {}
N 3350 870 3350 770 {}
N 3360 960 3360 870 {}
N 3370 1050 3370 960 {}
N 3380 1090 3380 1050 {}
N 3390 1270 3390 1090 {}
N 3400 1320 3400 1270 {}
N 3410 1410 3410 1320 {}
N 3420 1500 3420 1410 {}
N 3430 1590 3430 1500 {}
N 3440 1690 3440 1680 {}
N 3440 1680 3440 1590 {}
N 3450 1910 3450 1690 {}
N 3560 1950 3560 1940 {}
N 3690 1910 3690 1680 {}
N 3700 1950 3700 1910 {}
N 3740 1950 3740 1940 {}
N 3960 1950 3960 1940 {}
N 4020 1950 4020 1940 {}
N 3240 1740 3330 1740 {}
N 3330 1680 3340 1680 {}
N 3340 1600 3350 1600 {}
N 3350 1500 3360 1500 {}
N 3360 1410 3370 1410 {}
N 3370 1320 3380 1320 {}
N 3380 1180 3400 1180 {}
N 3400 1040 3410 1040 {}
N 3410 960 3420 960 {}
N 3420 870 3430 870 {}
N 3430 780 3440 780 {}
N 3440 720 3450 720 {}
N 3450 690 3700 690 {}
N 3450 450 3520 450 {}
N 3560 420 3700 420 {}
N 3700 420 3960 420 {}
N 3960 420 4100 420 {}
N 3240 1910 3240 1740 {}
N 3330 1740 3330 1680 {}
N 3340 1680 3340 1600 {}
N 3350 1600 3350 1500 {}
N 3360 1500 3360 1410 {}
N 3370 1410 3370 1320 {}
N 3380 1320 3380 1180 {}
N 3400 1180 3400 1040 {}
N 3410 1040 3410 960 {}
N 3420 960 3420 870 {}
N 3430 870 3430 780 {}
N 3440 780 3440 720 {}
N 3450 720 3450 690 {}
N 3450 690 3450 450 {}
N 3700 690 3700 420 {}
N 3700 420 3700 410 {}
N 2100 700 2130 700 {}
N 2440 700 2510 700 {}
N 2120 680 2130 680 {}
N 2130 660 2510 660 {}
N 2510 660 2740 660 {}
N 2740 650 2750 650 {}
N 2060 610 2130 610 {}
N 2510 430 2580 430 {}
N 2620 420 2750 420 {}
N 2750 420 3000 420 {}
N 3000 420 3120 420 {}
N 3120 400 3200 400 {}
N 2060 610 2060 430 {}
N 2100 870 2100 700 {}
N 2130 700 2130 680 {}
N 2130 680 2130 660 {}
N 2130 660 2130 610 {}
N 2440 870 2440 700 {}
N 2510 700 2510 660 {}
N 2510 660 2510 430 {}
N 2620 420 2620 400 {}
N 2740 660 2740 650 {}
N 2750 650 2750 420 {}
N 2750 420 2750 410 {}
N 3120 420 3120 400 {}
N 2440 1250 2510 1250 {}
N 2440 1100 2510 1100 {}
N 2440 1430 2440 1250 {}
N 2440 1100 2440 930 {}
N 2510 1250 2510 1100 {}
N 1100 1740 1180 1740 {}
N 1180 1700 1410 1700 {}
N 1410 1500 1420 1500 {}
N 1180 1490 1240 1490 {}
N 1280 1460 1420 1460 {}
N 1420 1460 1660 1460 {}
N 1660 1460 2140 1460 {}
N 2140 1460 2400 1460 {}
N 1100 1910 1100 1740 {}
N 1180 1740 1180 1700 {}
N 1180 1700 1180 1490 {}
N 1410 1700 1410 1500 {}
N 1420 1500 1420 1460 {}
N 1620 700 1650 700 {}
N 1650 660 1880 660 {}
N 1880 650 1890 650 {}
N 1650 450 1720 450 {}
N 1760 420 1890 420 {}
N 1890 420 1940 420 {}
N 1940 400 2020 400 {}
N 1620 870 1620 700 {}
N 1650 700 1650 660 {}
N 1650 660 1650 450 {}
N 1880 660 1880 650 {}
N 1890 650 1890 420 {}
N 1890 420 1890 400 {}
N 1940 420 1940 400 {}
N 680 1740 700 1740 {}
N 700 660 940 660 {}
N 700 430 780 430 {}
N 820 420 940 420 {}
N 940 420 980 420 {}
N 980 400 1060 400 {}
N 680 1910 680 1740 {}
N 700 1740 700 660 {}
N 700 660 700 430 {}
N 820 420 820 400 {}
N 940 660 940 420 {}
N 940 420 940 400 {}
N 980 420 980 400 {}
N 1620 1260 1650 1260 {}
N 1610 1190 1620 1190 {}
N 1520 1180 1610 1180 {}
N 1620 1180 1650 1180 {}
N 1620 1100 1650 1100 {}
N 1610 1190 1610 1180 {}
N 1620 1430 1620 1260 {}
N 1620 1190 1620 1180 {}
N 1620 1100 1620 930 {}
N 1650 1260 1650 1180 {}
N 1650 1180 1650 1100 {}
N 1760 1950 1900 1950 {}
N 1900 1950 1940 1950 {}
N 1890 1940 1900 1940 {}
N 1940 1940 2020 1940 {}
N 1650 1910 1720 1910 {}
N 1650 1710 1660 1710 {}
N 1660 1700 1890 1700 {}
N 1650 1690 1660 1690 {}
N 1620 1650 1650 1650 {}
N 1620 1650 1620 1490 {}
N 1650 1910 1650 1710 {}
N 1650 1690 1650 1650 {}
N 1660 1710 1660 1700 {}
N 1660 1700 1660 1690 {}
N 1760 1950 1760 1940 {}
N 1890 1940 1890 1700 {}
N 1900 1950 1900 1940 {}
N 1940 1950 1940 1940 {}
N 2100 1260 2130 1260 {}
N 1950 1210 1980 1210 {}
N 1940 1200 1950 1200 {}
N 1980 1200 1990 1200 {}
N 1960 1180 1990 1180 {}
N 1990 1180 2130 1180 {}
N 1980 1170 1990 1170 {}
N 1940 1160 1950 1160 {}
N 1970 1160 1980 1160 {}
N 1950 1150 1970 1150 {}
N 2100 1100 2130 1100 {}
N 1940 1200 1940 1160 {}
N 1950 1210 1950 1200 {}
N 1950 1160 1950 1150 {}
N 1970 1160 1970 1150 {}
N 1980 1210 1980 1200 {}
N 1980 1170 1980 1160 {}
N 1990 1200 1990 1180 {}
N 1990 1180 1990 1170 {}
N 2100 1430 2100 1260 {}
N 2100 1100 2100 930 {}
N 2130 1260 2130 1180 {}
N 2130 1180 2130 1100 {}
N 2750 1960 2760 1960 {}
N 2620 1950 2750 1950 {}
N 2750 1950 2790 1950 {}
N 3000 1950 3120 1950 {}
N 2790 1940 3000 1940 {}
N 3120 1940 3200 1940 {}
N 2510 1910 2580 1910 {}
N 2060 1740 2130 1740 {}
N 2740 1710 2750 1710 {}
N 2130 1700 2510 1700 {}
N 2510 1700 2740 1700 {}
N 2100 1660 2130 1660 {}
N 2440 1660 2510 1660 {}
N 2060 1910 2060 1740 {}
N 2100 1660 2100 1490 {}
N 2130 1740 2130 1700 {}
N 2130 1700 2130 1660 {}
N 2440 1660 2440 1490 {}
N 2510 1910 2510 1700 {}
N 2510 1700 2510 1660 {}
N 2620 1950 2620 1940 {}
N 2740 1710 2740 1700 {}
N 2750 1960 2750 1950 {}
N 2750 1950 2750 1710 {}
N 2790 1950 2790 1940 {}
N 3000 1950 3000 1940 {}
N 3120 1950 3120 1940 {}
N 3920 1740 3940 1740 {}
N 3800 1150 3940 1150 {}
N 3920 620 3940 620 {}
N 3800 1160 3800 1150 {}
N 3920 1910 3920 1740 {}
N 3920 620 3920 450 {}
N 3940 1740 3940 1150 {}
N 3940 1150 3940 620 {}
N 5110 930 5180 930 {}
N 5110 660 5320 660 {}
N 5110 650 5120 650 {}
N 5040 610 5110 610 {}
N 5040 610 5040 430 {}
N 5110 930 5110 660 {}
N 5110 660 5110 650 {}
N 5110 650 5110 610 {}
N 2960 1750 2980 1750 {}
N 3560 1590 3570 1590 {}
N 3570 1590 3580 1590 {}
N 3570 1550 3580 1550 {}
N 3560 1520 3580 1520 {}
N 3580 1490 3590 1490 {}
N 2980 1480 2990 1480 {}
N 2990 1460 3590 1460 {}
N 3590 1460 5360 1460 {}
N 2980 1440 2990 1440 {}
N 2770 1220 2780 1220 {}
N 2770 1200 2820 1200 {}
N 2980 1160 2990 1160 {}
N 2820 1150 2980 1150 {}
N 2980 1150 2990 1150 {}
N 5350 970 5360 970 {}
N 5220 960 5350 960 {}
N 2960 620 2980 620 {}
N 2770 1220 2770 1200 {}
N 2770 1200 2770 1150 {}
N 2820 1200 2820 1150 {}
N 2960 1910 2960 1750 {}
N 2960 620 2960 450 {}
N 2980 1750 2980 1480 {}
N 2980 1440 2980 1160 {}
N 2980 1150 2980 620 {}
N 2990 1480 2990 1460 {}
N 2990 1460 2990 1440 {}
N 2990 1160 2990 1150 {}
N 3570 1590 3570 1550 {}
N 3580 1550 3580 1520 {}
N 3580 1520 3580 1490 {}
N 3590 1490 3590 1460 {}
N 5350 970 5350 960 {}
N 5360 1460 5360 970 {}
