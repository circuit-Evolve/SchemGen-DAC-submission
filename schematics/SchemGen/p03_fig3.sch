v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2920 2400 2 0 {name="C_capacitor_14_0" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2920 8880 2 0 {name="C_capacitor_15_1" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6520 8880 2 0 {name="C_capacitor_16_2" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6520 2400 2 0 {name="C_capacitor_18_3" model=cap_mim_m3_1 W=1 L=1 MF=1 spiceprefix=X}
C {devices/gnd.sym} 5260 2880 0 0 {name="l_gnd_20_4" lab="GND"}
C {devices/gnd.sym} 4720 4840 0 0 {name="l_gnd_21_5" lab="GND"}
C {devices/gnd.sym} 4200 2880 0 0 {name="l_gnd_22_6" lab="GND"}
C {devices/gnd.sym} 4200 9340 0 0 {name="l_gnd_23_7" lab="GND"}
C {devices/gnd.sym} 5240 9400 0 0 {name="l_gnd_24_8" lab="GND"}
C {devices/gnd.sym} 4700 11320 0 0 {name="l_gnd_25_9" lab="GND"}
C {devices/gnd.sym} 2920 2800 0 0 {name="l_gnd_31_10" lab="GND"}
C {sky130_fd_pr/nfet3_01v8.sym} 5980 2940 0 1 {name="M_nmos_0_11"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4540 4320 0 0 {name="M_nmos_1_12"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4320 8880 0 1 {name="M_nmos_10_13"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5100 2400 0 0 {name="M_nmos_2_14"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4340 2400 0 1 {name="M_nmos_3_15"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4720 1620 1 0 {name="M_nmos_30_16"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4760 8100 1 0 {name="M_nmos_32_17"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3460 2880 0 0 {name="M_nmos_4_18"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5100 8780 0 0 {name="M_nmos_5_19"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4540 10800 0 0 {name="M_nmos_6_20"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5940 9360 0 1 {name="M_nmos_7_21"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3460 9360 0 0 {name="M_nmos_9_22"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5560 860 0 0 {name="M_pmos_11_23"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3880 920 0 1 {name="M_pmos_12_24"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5560 7380 0 0 {name="M_pmos_13_25"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3880 7380 0 1 {name="M_pmos_8_26"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 1320 9360 0 0 {name="p_port_17_27" lab="PORT_refined_7"}
C {devices/ipin.sym} 8220 9360 0 0 {name="p_port_19_28" lab="PORT_refined_2"}
C {devices/ipin.sym} 4220 10800 0 0 {name="p_port_33_29" lab="PORT_refined_9"}
C {devices/ipin.sym} 4220 4320 0 0 {name="p_port_34_30" lab="PORT_refined_3"}
C {devices/vdd.sym} 5800 6780 0 0 {name="l_vdd_26_31" lab="VDD"}
C {devices/vdd.sym} 3640 6780 0 0 {name="l_vdd_27_32" lab="VDD"}
C {devices/vdd.sym} 3640 320 0 0 {name="l_vdd_28_33" lab="VDD"}
C {devices/vdd.sym} 5800 320 0 0 {name="l_vdd_29_34" lab="VDD"}
N 4560 11120 4700 11120 {}
N 5120 9370 5240 9370 {}
N 4190 9340 4200 9340 {}
N 2920 8940 4190 8940 {}
N 5120 8940 6520 8940 {}
N 4190 8910 4300 8910 {}
N 4700 4840 4720 4840 {}
N 4560 4650 4700 4650 {}
N 4180 2880 4200 2880 {}
N 5120 2670 5260 2670 {}
N 5120 2460 6520 2460 {}
N 4180 2430 4320 2430 {}
N 2920 8940 2920 8910 {}
N 2920 2800 2920 2430 {}
N 4180 2880 4180 2430 {}
N 4190 9340 4190 8940 {}
N 4190 8940 4190 8910 {}
N 4560 11120 4560 10830 {}
N 4560 4650 4560 4350 {}
N 4700 11320 4700 11120 {}
N 4700 4840 4700 4650 {}
N 5120 9370 5120 8940 {}
N 5120 8940 5120 8810 {}
N 5120 2670 5120 2460 {}
N 5120 2460 5120 2430 {}
N 5240 9400 5240 9370 {}
N 5260 2880 5260 2670 {}
N 6520 8940 6520 8910 {}
N 6520 2460 6520 2430 {}
N 4560 3990 4720 3990 {}
N 4710 3800 4720 3800 {}
N 3650 3790 4710 3790 {}
N 4710 3790 5790 3790 {}
N 3640 3780 3650 3780 {}
N 3630 3760 3640 3760 {}
N 3480 3210 3630 3210 {}
N 5790 2970 5960 2970 {}
N 3480 3210 3480 2910 {}
N 3630 3760 3630 3210 {}
N 3640 3780 3640 3760 {}
N 3650 3790 3650 3780 {}
N 4560 4290 4560 3990 {}
N 4710 3800 4710 3790 {}
N 4720 3990 4720 3800 {}
N 5790 3790 5790 2970 {}
N 3480 9030 3650 9030 {}
N 3650 8830 4300 8830 {}
N 4300 8780 4700 8780 {}
N 4700 8780 5080 8780 {}
N 2740 8290 2920 8290 {}
N 2920 8290 3650 8290 {}
N 2730 8270 2740 8270 {}
N 4700 8120 4730 8120 {}
N 3650 7410 3860 7410 {}
N 2730 5440 2740 5440 {}
N 2740 5420 2750 5420 {}
N 2750 5410 3840 5410 {}
N 3840 5400 3890 5400 {}
N 3890 5390 3940 5390 {}
N 3940 5380 3990 5380 {}
N 3990 5370 4040 5370 {}
N 4040 5360 4090 5360 {}
N 4090 5350 4140 5350 {}
N 4140 5340 4190 5340 {}
N 4190 5330 4240 5330 {}
N 4240 5320 4290 5320 {}
N 4290 5310 4340 5310 {}
N 4340 5300 4390 5300 {}
N 4390 5290 4440 5290 {}
N 4440 5280 4490 5280 {}
N 4490 5270 4540 5270 {}
N 4540 5260 4590 5260 {}
N 4590 5240 4840 5240 {}
N 4840 5210 4850 5210 {}
N 4850 5200 4900 5200 {}
N 4900 5190 4950 5190 {}
N 4950 5180 5000 5180 {}
N 5000 5170 5050 5170 {}
N 5050 5160 5100 5160 {}
N 5100 5150 5150 5150 {}
N 5150 5140 5200 5140 {}
N 5200 5130 5250 5130 {}
N 5250 5120 5300 5120 {}
N 5300 5110 5350 5110 {}
N 5350 5100 5400 5100 {}
N 5400 5090 5450 5090 {}
N 5450 5080 5500 5080 {}
N 5500 5070 5550 5070 {}
N 5550 5060 5600 5060 {}
N 5600 5050 6690 5050 {}
N 6680 2900 6690 2900 {}
N 6000 2890 6680 2890 {}
N 2730 8270 2730 5440 {}
N 2740 8290 2740 8270 {}
N 2740 5440 2740 5420 {}
N 2750 5420 2750 5410 {}
N 2920 8850 2920 8290 {}
N 3480 9330 3480 9030 {}
N 3650 9030 3650 8830 {}
N 3650 8830 3650 8290 {}
N 3650 8290 3650 7410 {}
N 3840 5410 3840 5400 {}
N 3890 5400 3890 5390 {}
N 3940 5390 3940 5380 {}
N 3990 5380 3990 5370 {}
N 4040 5370 4040 5360 {}
N 4090 5360 4090 5350 {}
N 4140 5350 4140 5340 {}
N 4190 5340 4190 5330 {}
N 4240 5330 4240 5320 {}
N 4290 5320 4290 5310 {}
N 4300 8850 4300 8830 {}
N 4300 8830 4300 8780 {}
N 4340 5310 4340 5300 {}
N 4390 5300 4390 5290 {}
N 4440 5290 4440 5280 {}
N 4490 5280 4490 5270 {}
N 4540 5270 4540 5260 {}
N 4590 5260 4590 5240 {}
N 4700 8780 4700 8120 {}
N 4840 5240 4840 5210 {}
N 4850 5210 4850 5200 {}
N 4900 5200 4900 5190 {}
N 4950 5190 4950 5180 {}
N 5000 5180 5000 5170 {}
N 5050 5170 5050 5160 {}
N 5100 5160 5100 5150 {}
N 5150 5150 5150 5140 {}
N 5200 5140 5200 5130 {}
N 5250 5130 5250 5120 {}
N 5300 5120 5300 5110 {}
N 5350 5110 5350 5100 {}
N 5400 5100 5400 5090 {}
N 5450 5090 5450 5080 {}
N 5500 5080 5500 5070 {}
N 5550 5070 5550 5060 {}
N 5600 5060 5600 5050 {}
N 6000 2940 6000 2890 {}
N 6680 2900 6680 2890 {}
N 6690 5050 6690 2900 {}
N 3630 7350 3860 7350 {}
N 5580 7050 5800 7050 {}
N 5790 7030 5800 7030 {}
N 3630 6780 3640 6780 {}
N 5790 6780 5800 6780 {}
N 3630 890 3860 890 {}
N 5580 580 5800 580 {}
N 5790 550 5800 550 {}
N 3630 320 3640 320 {}
N 5790 320 5800 320 {}
N 3630 7350 3630 6780 {}
N 3630 890 3630 320 {}
N 5580 7350 5580 7050 {}
N 5580 830 5580 580 {}
N 5790 7030 5790 6780 {}
N 5790 550 5790 320 {}
N 5790 320 5790 310 {}
N 5800 7050 5800 7030 {}
N 5800 580 5800 550 {}
N 4700 930 4710 930 {}
N 3900 910 4710 910 {}
N 4710 910 4720 910 {}
N 4720 910 5300 910 {}
N 4720 880 4740 880 {}
N 5300 860 5540 860 {}
N 4710 700 4720 700 {}
N 3900 920 3900 910 {}
N 4710 930 4710 910 {}
N 4710 700 4710 690 {}
N 4720 910 4720 880 {}
N 4720 880 4720 700 {}
N 5300 910 5300 860 {}
N 3900 7390 4720 7390 {}
N 4720 7390 5300 7390 {}
N 5300 7380 5540 7380 {}
N 4710 7190 4720 7190 {}
N 3900 7390 3900 7380 {}
N 4710 7190 4710 7180 {}
N 4720 7390 4720 7190 {}
N 5300 7390 5300 7380 {}
N 5960 9360 5980 9360 {}
N 5980 9360 5990 9360 {}
N 8220 9360 8240 9360 {}
N 8240 9360 8250 9360 {}
N 6530 9340 8240 9340 {}
N 5980 8950 6530 8950 {}
N 6530 8930 6540 8930 {}
N 6540 8300 6690 8300 {}
N 6690 8290 6700 8290 {}
N 5120 2900 5280 2900 {}
N 6690 2890 6700 2890 {}
N 5280 2880 5960 2880 {}
N 6530 2880 6690 2880 {}
N 5110 2680 5120 2680 {}
N 5960 2470 6530 2470 {}
N 5060 2450 5110 2450 {}
N 6530 2450 6540 2450 {}
N 5040 2410 5060 2410 {}
N 4360 2400 4390 2400 {}
N 4390 2350 4770 2350 {}
N 4770 2350 5040 2350 {}
N 5040 2350 5120 2350 {}
N 6520 2350 6540 2350 {}
N 4750 1640 4770 1640 {}
N 4770 1640 4780 1640 {}
N 4780 920 5580 920 {}
N 4390 2400 4390 2350 {}
N 4770 2350 4770 1640 {}
N 4780 1640 4780 920 {}
N 5040 2410 5040 2350 {}
N 5060 2450 5060 2410 {}
N 5110 2680 5110 2450 {}
N 5120 2900 5120 2680 {}
N 5120 2370 5120 2350 {}
N 5120 2350 5120 2340 {}
N 5280 2900 5280 2880 {}
N 5580 920 5580 890 {}
N 5960 2910 5960 2880 {}
N 5960 2880 5960 2470 {}
N 5980 9360 5980 8950 {}
N 6520 2370 6520 2350 {}
N 6520 2350 6520 2340 {}
N 6530 9340 6530 8950 {}
N 6530 8950 6530 8930 {}
N 6530 2880 6530 2470 {}
N 6530 2470 6530 2450 {}
N 6540 8930 6540 8300 {}
N 6540 2450 6540 2350 {}
N 6690 8300 6690 8290 {}
N 6690 2890 6690 2880 {}
N 6700 8290 6700 2890 {}
N 8240 9360 8240 9340 {}
N 4220 4330 4320 4330 {}
N 4320 4320 4520 4320 {}
N 4220 4330 4220 4320 {}
N 4320 4330 4320 4320 {}
N 4710 1290 4720 1290 {}
N 4710 1290 4710 1280 {}
N 4720 1600 4720 1290 {}
N 5220 9420 5260 9420 {}
N 5110 9380 5220 9380 {}
N 5260 9330 5790 9330 {}
N 5790 9330 5920 9330 {}
N 4340 8880 5110 8880 {}
N 5120 8500 5240 8500 {}
N 5220 8290 5240 8290 {}
N 5240 8290 5260 8290 {}
N 5820 8290 6520 8290 {}
N 6520 8290 6680 8290 {}
N 4790 8280 5220 8280 {}
N 5260 8280 5740 8280 {}
N 5800 8280 5820 8280 {}
N 6680 8280 6690 8280 {}
N 5740 8270 5790 8270 {}
N 5790 8270 5800 8270 {}
N 5580 7700 5790 7700 {}
N 5600 5410 6690 5410 {}
N 5550 5400 5600 5400 {}
N 5500 5390 5550 5390 {}
N 5450 5380 5500 5380 {}
N 5400 5370 5450 5370 {}
N 5350 5360 5400 5360 {}
N 5300 5350 5350 5350 {}
N 5250 5340 5300 5340 {}
N 5200 5330 5250 5330 {}
N 5150 5320 5200 5320 {}
N 5100 5310 5150 5310 {}
N 5050 5300 5100 5300 {}
N 5000 5290 5050 5290 {}
N 4950 5280 5000 5280 {}
N 4900 5270 4950 5270 {}
N 4850 5260 4900 5260 {}
N 4720 5250 4850 5250 {}
N 4540 5200 4720 5200 {}
N 4490 5190 4540 5190 {}
N 4440 5180 4490 5180 {}
N 4390 5170 4440 5170 {}
N 4340 5160 4390 5160 {}
N 4290 5150 4340 5150 {}
N 4240 5140 4290 5140 {}
N 4190 5130 4240 5130 {}
N 4140 5120 4190 5120 {}
N 4090 5110 4140 5110 {}
N 4040 5100 4090 5100 {}
N 3990 5090 4040 5090 {}
N 3940 5080 3990 5080 {}
N 3890 5070 3940 5070 {}
N 3840 5060 3890 5060 {}
N 2750 5050 3840 5050 {}
N 2740 5040 2750 5040 {}
N 2730 5020 2740 5020 {}
N 2730 2910 2740 2910 {}
N 2740 2890 3250 2890 {}
N 3250 2880 3440 2880 {}
N 2730 5020 2730 2910 {}
N 2740 5040 2740 5020 {}
N 2740 2910 2740 2890 {}
N 2750 5050 2750 5040 {}
N 3250 2890 3250 2880 {}
N 3840 5060 3840 5050 {}
N 3890 5070 3890 5060 {}
N 3940 5080 3940 5070 {}
N 3990 5090 3990 5080 {}
N 4040 5100 4040 5090 {}
N 4090 5110 4090 5100 {}
N 4140 5120 4140 5110 {}
N 4190 5130 4190 5120 {}
N 4240 5140 4240 5130 {}
N 4290 5150 4290 5140 {}
N 4340 5160 4340 5150 {}
N 4390 5170 4390 5160 {}
N 4440 5180 4440 5170 {}
N 4490 5190 4490 5180 {}
N 4540 5200 4540 5190 {}
N 4720 5250 4720 5200 {}
N 4790 8280 4790 8120 {}
N 4850 5260 4850 5250 {}
N 4900 5270 4900 5260 {}
N 4950 5280 4950 5270 {}
N 5000 5290 5000 5280 {}
N 5050 5300 5050 5290 {}
N 5100 5310 5100 5300 {}
N 5110 9380 5110 8880 {}
N 5120 8750 5120 8500 {}
N 5150 5320 5150 5310 {}
N 5200 5330 5200 5320 {}
N 5220 9420 5220 9380 {}
N 5220 8290 5220 8280 {}
N 5240 8500 5240 8290 {}
N 5250 5340 5250 5330 {}
N 5260 9420 5260 9330 {}
N 5260 8290 5260 8280 {}
N 5300 5350 5300 5340 {}
N 5350 5360 5350 5350 {}
N 5400 5370 5400 5360 {}
N 5450 5380 5450 5370 {}
N 5500 5390 5500 5380 {}
N 5550 5400 5550 5390 {}
N 5580 7700 5580 7410 {}
N 5600 5410 5600 5400 {}
N 5740 8280 5740 8270 {}
N 5790 9330 5790 8270 {}
N 5790 8270 5790 7700 {}
N 5800 8280 5800 8270 {}
N 5820 8290 5820 8280 {}
N 6520 8850 6520 8290 {}
N 6680 8290 6680 8280 {}
N 6690 8280 6690 5410 {}
N 4720 8080 4760 8080 {}
N 4710 7800 4720 7800 {}
N 4710 7800 4710 7790 {}
N 4720 8080 4720 7800 {}
N 1320 9370 1620 9370 {}
N 1700 9370 3240 9370 {}
N 1620 9360 1660 9360 {}
N 1660 9360 1700 9360 {}
N 3240 9360 3440 9360 {}
N 4180 2900 4220 2900 {}
N 4170 2890 4180 2890 {}
N 3480 2560 3650 2560 {}
N 4220 2450 4380 2450 {}
N 4380 2410 4400 2410 {}
N 4400 2400 5080 2400 {}
N 3650 2350 4170 2350 {}
N 4170 2350 4320 2350 {}
N 1660 1820 1670 1820 {}
N 1670 1810 2920 1810 {}
N 2920 1810 3650 1810 {}
N 3650 1640 4690 1640 {}
N 3650 950 3860 950 {}
N 1320 9370 1320 9360 {}
N 1620 9370 1620 9360 {}
N 1660 9360 1660 1820 {}
N 1670 1820 1670 1810 {}
N 1700 9370 1700 9360 {}
N 2920 2370 2920 1810 {}
N 3240 9370 3240 9360 {}
N 3480 2850 3480 2560 {}
N 3650 2560 3650 2350 {}
N 3650 2350 3650 1810 {}
N 3650 1810 3650 1640 {}
N 3650 1640 3650 950 {}
N 4170 2890 4170 2350 {}
N 4180 2900 4180 2890 {}
N 4220 2900 4220 2450 {}
N 4320 2370 4320 2350 {}
N 4320 2350 4320 2340 {}
N 4380 2450 4380 2410 {}
N 4400 2410 4400 2400 {}
N 4560 10470 4710 10470 {}
N 3650 10270 4710 10270 {}
N 4710 10270 5790 10270 {}
N 3640 10260 3650 10260 {}
N 3630 10240 3640 10240 {}
N 3480 9680 3630 9680 {}
N 5790 9390 5920 9390 {}
N 3480 9680 3480 9390 {}
N 3630 10240 3630 9680 {}
N 3640 10260 3640 10240 {}
N 3650 10270 3650 10260 {}
N 4560 10770 4560 10470 {}
N 4710 10470 4710 10270 {}
N 5790 10270 5790 9390 {}
N 4220 10810 4320 10810 {}
N 4320 10800 4520 10800 {}
N 4220 10810 4220 10800 {}
N 4320 10810 4320 10800 {}
