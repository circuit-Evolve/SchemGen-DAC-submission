v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/gnd.sym} 3840 3920 0 0 {name="l_gnd_19_0" lab="GND"}
C {devices/gnd.sym} 2420 2220 0 0 {name="l_gnd_20_1" lab="GND"}
C {devices/gnd.sym} 5240 2200 0 0 {name="l_gnd_21_2" lab="GND"}
C {devices/gnd.sym} 7080 1600 0 0 {name="l_gnd_22_3" lab="GND"}
C {devices/gnd.sym} 600 1620 0 0 {name="l_gnd_23_4" lab="GND"}
C {sky130_fd_pr/nfet3_01v8.sym} 2540 1260 0 1 {name="M_nmos_0_5"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 480 1260 0 0 {name="M_nmos_1_6"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5140 1260 0 0 {name="M_nmos_2_7"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2320 1860 0 0 {name="M_nmos_3_8"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7180 1260 0 1 {name="M_nmos_4_9"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 3680 0 0 {name="M_nmos_5_10"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3080 3140 0 0 {name="M_nmos_6_11"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5340 1860 0 1 {name="M_nmos_8_12"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4620 3140 0 1 {name="M_nmos_9_13"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7220 560 0 1 {name="M_pmos_10_14"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5380 560 0 1 {name="M_pmos_11_15"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2280 560 0 0 {name="M_pmos_12_16"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4480 560 0 1 {name="M_pmos_14_17"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3320 2520 0 1 {name="M_pmos_15_18"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 460 540 0 0 {name="M_pmos_16_19"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4380 2500 0 0 {name="M_pmos_17_20"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3200 540 0 0 {name="M_pmos_18_21"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1480 560 0 1 {name="M_pmos_cross_13_22"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6180 560 0 0 {name="M_pmos_cross_7_23"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 5240 940 0 0 {name="p_port_31_24" lab="PORT_refined_2"}
T {Out} 5270 900 0 0 0.25 0.25 {}
C {devices/ipin.sym} 3300 1180 0 0 {name="p_port_32_25" lab="PORT_refined_4"}
T {Outb} 3330 1140 0 0 0.25 0.25 {}
C {devices/ipin.sym} 3000 3160 0 0 {name="p_port_33_26" lab="PORT_refined_10"}
T {Input} 3030 3120 0 0 0.25 0.25 {}
C {devices/ipin.sym} 4700 3160 0 0 {name="p_port_34_27" lab="PORT_refined_11"}
T {REF} 4730 3120 0 0 0.25 0.25 {}
C {devices/ipin.sym} 3400 2520 0 0 {name="p_port_35_28" lab="PORT_refined_13"}
T {Read} 3430 2480 0 0 0.25 0.25 {}
C {devices/ipin.sym} 3640 3680 0 0 {name="p_port_36_29" lab="PORT_refined_13"}
T {Read} 3670 3640 0 0 0.25 0.25 {}
C {devices/vdd.sym} 600 240 0 0 {name="l_vdd_30_30" lab="VDD"}
N 3740 3860 3840 3860 {}
N 2340 2040 2420 2040 {}
N 5240 1890 5320 1890 {}
N 590 1620 600 1620 {}
N 7070 1600 7080 1600 {}
N 500 1450 590 1450 {}
N 7070 1290 7160 1290 {}
N 500 1450 500 1290 {}
N 590 1620 590 1450 {}
N 2340 2040 2340 1890 {}
N 2420 2220 2420 2040 {}
N 3740 3860 3740 3710 {}
N 3840 3920 3840 3860 {}
N 5240 2200 5240 1890 {}
N 7070 1600 7070 1290 {}
N 3100 2940 3180 2940 {}
N 210 2820 3180 2820 {}
N 3180 2550 3300 2550 {}
N 210 1260 460 1260 {}
N 210 560 300 560 {}
N 300 540 440 540 {}
N 210 2820 210 1260 {}
N 210 1260 210 560 {}
N 300 560 300 540 {}
N 3100 3110 3100 2940 {}
N 3180 2940 3180 2820 {}
N 3180 2820 3180 2550 {}
N 3000 3160 3020 3160 {}
N 3020 3160 3030 3160 {}
N 2870 3140 3020 3140 {}
N 3020 3140 3060 3140 {}
N 3020 3160 3020 3140 {}
N 4700 3160 4720 3160 {}
N 4720 3160 4730 3160 {}
N 4640 3140 4720 3140 {}
N 4720 3140 4840 3140 {}
N 4720 3160 4720 3140 {}
N 3180 2490 3300 2490 {}
N 4400 2320 4520 2320 {}
N 3140 2250 3180 2250 {}
N 3180 2250 4340 2250 {}
N 4340 2250 4520 2250 {}
N 4520 2250 4580 2250 {}
N 4330 970 4340 970 {}
N 4330 530 4340 530 {}
N 4340 530 4460 530 {}
N 5240 530 5360 530 {}
N 6150 530 6200 530 {}
N 7080 530 7200 530 {}
N 1460 380 1510 380 {}
N 2300 370 2420 370 {}
N 480 360 600 360 {}
N 3220 360 3340 360 {}
N 540 240 600 240 {}
N 600 240 1510 240 {}
N 1510 240 2420 240 {}
N 2420 240 3340 240 {}
N 3340 240 4340 240 {}
N 4340 240 5240 240 {}
N 5240 240 6150 240 {}
N 6150 240 7080 240 {}
N 7080 240 7120 240 {}
N 480 510 480 360 {}
N 600 360 600 240 {}
N 1460 530 1460 380 {}
N 1510 380 1510 240 {}
N 2300 530 2300 370 {}
N 2420 370 2420 240 {}
N 3180 2490 3180 2250 {}
N 3220 510 3220 360 {}
N 3340 360 3340 240 {}
N 4330 970 4330 530 {}
N 4340 2250 4340 970 {}
N 4340 530 4340 240 {}
N 4400 2470 4400 2320 {}
N 4520 2320 4520 2250 {}
N 5240 530 5240 240 {}
N 6150 530 6150 240 {}
N 7080 530 7080 240 {}
N 3600 3680 3640 3680 {}
N 3640 3680 3700 3680 {}
N 3510 3670 3600 3670 {}
N 3400 2520 3420 2520 {}
N 3420 2520 3430 2520 {}
N 3600 2520 4220 2520 {}
N 3340 2510 3420 2510 {}
N 3420 2510 3600 2510 {}
N 4220 2500 4360 2500 {}
N 3340 2520 3340 2510 {}
N 3420 2520 3420 2510 {}
N 3600 3680 3600 3670 {}
N 3600 3670 3600 2520 {}
N 3600 2520 3600 2510 {}
N 4220 2520 4220 2500 {}
N 2560 1260 2920 1260 {}
N 5160 1060 5240 1060 {}
N 4340 960 5240 960 {}
N 5240 940 5270 940 {}
N 2920 850 2930 850 {}
N 2930 840 4340 840 {}
N 4340 840 5240 840 {}
N 4340 590 4460 590 {}
N 5240 590 5360 590 {}
N 2920 560 3040 560 {}
N 3040 540 3180 540 {}
N 2920 1260 2920 850 {}
N 2920 850 2920 560 {}
N 2930 850 2930 840 {}
N 3040 560 3040 540 {}
N 4340 960 4340 840 {}
N 4340 840 4340 590 {}
N 5160 1230 5160 1060 {}
N 5240 1060 5240 960 {}
N 5240 960 5240 940 {}
N 5240 940 5240 840 {}
N 5240 840 5240 590 {}
N 5240 1830 5320 1830 {}
N 5240 1560 6140 1560 {}
N 6140 1530 6150 1530 {}
N 5160 1440 5240 1440 {}
N 6150 590 6200 590 {}
N 5160 1440 5160 1290 {}
N 5240 1830 5240 1560 {}
N 5240 1560 5240 1440 {}
N 6140 1560 6140 1530 {}
N 6150 1530 6150 590 {}
N 4780 1260 5120 1260 {}
N 2420 1230 2520 1230 {}
N 3300 1180 3320 1180 {}
N 3320 1180 3330 1180 {}
N 3140 1170 3320 1170 {}
N 3320 1170 4780 1170 {}
N 3130 1160 3140 1160 {}
N 4780 1160 4790 1160 {}
N 2420 980 2430 980 {}
N 3130 980 3140 980 {}
N 2420 970 3140 970 {}
N 3140 970 3340 970 {}
N 2300 740 2420 740 {}
N 3220 720 3340 720 {}
N 4500 560 4780 560 {}
N 2300 740 2300 590 {}
N 2420 1230 2420 980 {}
N 2420 980 2420 970 {}
N 2420 970 2420 740 {}
N 3130 1160 3130 980 {}
N 3140 1170 3140 1160 {}
N 3140 980 3140 970 {}
N 3220 720 3220 570 {}
N 3320 1360 3320 1180 {}
N 3320 1180 3320 1170 {}
N 3340 970 3340 720 {}
N 4780 1260 4780 1170 {}
N 4780 1170 4780 1160 {}
N 4780 1160 4780 560 {}
N 2340 1660 2420 1660 {}
N 1510 1560 2420 1560 {}
N 2420 1290 2520 1290 {}
N 1460 740 1510 740 {}
N 1460 740 1460 590 {}
N 1510 1560 1510 740 {}
N 2340 1830 2340 1660 {}
N 2420 1660 2420 1560 {}
N 2420 1560 2420 1290 {}
N 1020 1860 2300 1860 {}
N 500 1080 600 1080 {}
N 610 910 1020 910 {}
N 600 900 610 900 {}
N 480 730 600 730 {}
N 1020 580 1030 580 {}
N 1030 570 1220 570 {}
N 1500 570 2120 570 {}
N 1220 560 1500 560 {}
N 2120 560 2260 560 {}
N 480 730 480 570 {}
N 500 1230 500 1080 {}
N 600 1080 600 900 {}
N 600 900 600 730 {}
N 610 910 610 900 {}
N 1020 1860 1020 910 {}
N 1020 910 1020 580 {}
N 1030 580 1030 570 {}
N 1220 570 1220 560 {}
N 1500 570 1500 560 {}
N 2120 570 2120 560 {}
N 5360 1860 6630 1860 {}
N 7080 1230 7160 1230 {}
N 6620 900 6630 900 {}
N 6630 900 7080 900 {}
N 7080 900 7090 900 {}
N 7080 590 7200 590 {}
N 5400 560 6160 560 {}
N 6160 560 6630 560 {}
N 6630 1860 6630 900 {}
N 6630 900 6630 560 {}
N 7080 1230 7080 900 {}
N 7080 900 7080 590 {}
N 4520 3110 4600 3110 {}
N 4500 2830 4520 2830 {}
N 4520 2820 7440 2820 {}
N 4400 2680 4520 2680 {}
N 7200 1260 7440 1260 {}
N 7400 580 7440 580 {}
N 7240 570 7400 570 {}
N 4400 2680 4400 2530 {}
N 4520 3110 4520 2830 {}
N 4520 2830 4520 2820 {}
N 4520 2820 4520 2680 {}
N 7240 570 7240 560 {}
N 7400 580 7400 570 {}
N 7440 2820 7440 1260 {}
N 7440 1260 7440 580 {}
N 3740 3480 3840 3480 {}
N 3180 3400 3840 3400 {}
N 3840 3400 4520 3400 {}
N 3100 3320 3180 3320 {}
N 4520 3170 4600 3170 {}
N 3100 3320 3100 3170 {}
N 3180 3400 3180 3320 {}
N 3740 3650 3740 3480 {}
N 3840 3480 3840 3400 {}
N 4520 3400 4520 3170 {}
