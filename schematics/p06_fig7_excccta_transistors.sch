v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 14920 3580 2 0 {name="I_current_0_0" value=1m}
C {devices/isource.sym} 9240 3600 2 0 {name="I_current_19_1" value=1m}
C {devices/isource.sym} 700 3140 2 0 {name="I_current_33_2" value=1m}
C {devices/gnd.sym} 16120 2520 0 0 {name="l_gnd_54_3" lab="GND"}
C {devices/gnd.sym} 360 3000 0 0 {name="l_gnd_63_4" lab="GND"}
C {sky130_fd_pr/nfet3_01v8.sym} 18220 3280 0 1 {name="M_nmos_1_5"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12560 3300 0 1 {name="M_nmos_10_6"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10040 2200 0 1 {name="M_nmos_2_7"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 860 3800 0 1 {name="M_nmos_24_8"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11100 3320 0 1 {name="M_nmos_27_9"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 16760 3300 0 1 {name="M_nmos_28_10"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15680 2200 0 1 {name="M_nmos_3_11"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7660 3760 0 0 {name="M_nmos_30_12"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2620 3760 0 0 {name="M_nmos_31_13"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4000 3780 0 1 {name="M_nmos_34_14"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11700 3320 0 0 {name="M_nmos_35_15"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5660 3760 0 0 {name="M_nmos_36_16"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6260 3780 0 1 {name="M_nmos_37_17"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 17360 3280 0 0 {name="M_nmos_40_18"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4280 1720 0 0 {name="M_nmos_41_19"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8440 2200 0 0 {name="M_nmos_5_20"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2960 1700 0 1 {name="M_nmos_6_21"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 19020 3280 0 0 {name="M_nmos_7_22"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14080 2200 0 0 {name="M_nmos_8_23"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13360 3320 0 0 {name="M_nmos_9_24"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3780 1700 0 1 {name="M_nmos_cross_42_25"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5060 3760 0 1 {name="M_nmos_cross_45_26"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1720 3760 0 1 {name="M_nmos_cross_46_27"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6960 3740 0 0 {name="M_nmos_cross_49_28"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14480 780 0 1 {name="M_pmos_11_29"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 17360 760 0 0 {name="M_pmos_12_30"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11700 780 0 0 {name="M_pmos_13_31"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13380 780 0 0 {name="M_pmos_14_32"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4000 720 0 1 {name="M_pmos_15_33"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 720 0 0 {name="M_pmos_16_34"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12540 820 0 1 {name="M_pmos_17_35"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 18200 800 0 1 {name="M_pmos_18_36"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7660 720 0 0 {name="M_pmos_20_37"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 19040 800 0 0 {name="M_pmos_21_38"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2640 720 0 0 {name="M_pmos_22_39"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 16380 1360 0 0 {name="M_pmos_23_40"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15640 1360 0 1 {name="M_pmos_25_41"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9980 1360 0 1 {name="M_pmos_26_42"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2960 2700 0 1 {name="M_pmos_29_43"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10740 1380 0 0 {name="M_pmos_32_44"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1920 680 0 1 {name="M_pmos_38_45"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4280 2680 0 0 {name="M_pmos_39_46"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8840 800 0 1 {name="M_pmos_4_47"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6280 680 0 1 {name="M_pmos_44_48"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5060 720 0 1 {name="M_pmos_cross_43_49"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 2700 0 1 {name="M_pmos_cross_47_50"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7080 720 0 1 {name="M_pmos_cross_48_51"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 5280 1840 0 0 {name="p_port_50_52" lab="PORT_refined_20"}
C {devices/ipin.sym} 19520 4100 0 0 {name="p_port_51_53" lab="PORT_refined_0"}
C {devices/ipin.sym} 19440 1720 0 0 {name="p_port_52_54" lab="PORT_refined_6"}
C {devices/ipin.sym} 6040 1840 0 0 {name="p_port_53_55" lab="PORT_refined_25"}
C {devices/ipin.sym} 7320 1840 0 0 {name="p_port_55_56" lab="PORT_refined_24"}
C {devices/ipin.sym} 19540 360 0 0 {name="p_port_56_57" lab="VDD"}
C {devices/ipin.sym} 8040 1820 0 0 {name="p_port_57_58" lab="PORT_refined_4"}
C {devices/ipin.sym} 2460 2200 0 0 {name="p_port_58_59" lab="PORT_refined_14"}
C {devices/ipin.sym} 13920 1800 0 0 {name="p_port_60_60" lab="PORT_refined_31"}
T {O1} 13950 1760 0 0 0.25 0.25 {}
C {devices/ipin.sym} 3560 2200 0 0 {name="p_port_61_61" lab="PORT_refined_22"}
T {X1} 3590 2160 0 0 0.25 0.25 {}
C {devices/ipin.sym} 3960 2200 0 0 {name="p_port_62_62" lab="PORT_refined_17"}
T {X2} 3990 2160 0 0 0.25 0.25 {}
C {devices/vdd.sym} 9820 480 0 0 {name="l_vdd_59_63" lab="VDD"}
C {devices/vdd.sym} 15480 460 0 0 {name="l_vdd_60_64" lab="VDD"}
N 700 4110 1710 4110 {}
N 1790 4110 2740 4110 {}
N 2820 4110 3780 4110 {}
N 3860 4110 5040 4110 {}
N 5120 4110 5790 4110 {}
N 5870 4110 6050 4110 {}
N 6130 4110 6750 4110 {}
N 6760 4110 6840 4110 {}
N 6840 4110 7060 4110 {}
N 7140 4110 7790 4110 {}
N 7870 4110 9200 4110 {}
N 9280 4110 10860 4110 {}
N 10940 4110 11850 4110 {}
N 11930 4110 12300 4110 {}
N 12380 4110 13520 4110 {}
N 13600 4110 14860 4110 {}
N 14940 4110 16520 4110 {}
N 16600 4110 17500 4110 {}
N 17580 4110 17960 4110 {}
N 18040 4110 19190 4110 {}
N 19270 4110 19510 4110 {}
N 690 4100 700 4100 {}
N 1710 4100 1750 4100 {}
N 1750 4100 1790 4100 {}
N 2740 4100 2780 4100 {}
N 2780 4100 2820 4100 {}
N 3780 4100 3820 4100 {}
N 3820 4100 3860 4100 {}
N 5040 4100 5080 4100 {}
N 5080 4100 5120 4100 {}
N 5790 4100 5830 4100 {}
N 5830 4100 5870 4100 {}
N 6050 4100 6090 4100 {}
N 6090 4100 6130 4100 {}
N 6750 4100 6760 4100 {}
N 7060 4100 7100 4100 {}
N 7100 4100 7140 4100 {}
N 7790 4100 7830 4100 {}
N 7830 4100 7870 4100 {}
N 9200 4100 9240 4100 {}
N 9240 4100 9280 4100 {}
N 10860 4100 10900 4100 {}
N 10900 4100 10940 4100 {}
N 11850 4100 11890 4100 {}
N 11890 4100 11930 4100 {}
N 12300 4100 12340 4100 {}
N 12340 4100 12380 4100 {}
N 13520 4100 13560 4100 {}
N 13560 4100 13600 4100 {}
N 14860 4100 14900 4100 {}
N 14900 4100 14940 4100 {}
N 16520 4100 16560 4100 {}
N 16560 4100 16600 4100 {}
N 17500 4100 17540 4100 {}
N 17540 4100 17580 4100 {}
N 17960 4100 18000 4100 {}
N 18000 4100 18040 4100 {}
N 19190 4100 19230 4100 {}
N 19230 4100 19270 4100 {}
N 19510 4100 19520 4100 {}
N 6840 4090 6850 4090 {}
N 6750 4080 6770 4080 {}
N 6830 4080 6840 4080 {}
N 6850 4080 6860 4080 {}
N 6820 4070 6830 4070 {}
N 5820 4050 5830 4050 {}
N 11880 4050 11890 4050 {}
N 17990 4050 18000 4050 {}
N 19220 4050 19230 4050 {}
N 1700 3970 1750 3970 {}
N 5040 3970 5080 3970 {}
N 5680 3970 5820 3970 {}
N 7680 3970 7830 3970 {}
N 2640 3960 2780 3960 {}
N 6980 3930 7100 3930 {}
N 690 3830 840 3830 {}
N 3820 3810 3980 3810 {}
N 6090 3810 6240 3810 {}
N 11880 3750 11890 3750 {}
N 17990 3740 18000 3740 {}
N 17990 3720 18000 3720 {}
N 11880 3690 11890 3690 {}
N 11720 3610 11880 3610 {}
N 14900 3610 14920 3610 {}
N 13380 3600 13560 3600 {}
N 17380 3590 17540 3590 {}
N 19040 3580 19220 3580 {}
N 10900 3350 11080 3350 {}
N 12340 3330 12540 3330 {}
N 16560 3330 16740 3330 {}
N 17990 3310 18200 3310 {}
N 690 4100 690 3830 {}
N 700 4110 700 4100 {}
N 1700 3970 1700 3790 {}
N 1710 4110 1710 4100 {}
N 1750 4100 1750 3970 {}
N 1790 4110 1790 4100 {}
N 2640 3960 2640 3790 {}
N 2740 4110 2740 4100 {}
N 2780 4100 2780 3960 {}
N 2820 4110 2820 4100 {}
N 3780 4110 3780 4100 {}
N 3820 4100 3820 3810 {}
N 3860 4110 3860 4100 {}
N 5040 4110 5040 4100 {}
N 5040 3970 5040 3790 {}
N 5080 4100 5080 3970 {}
N 5120 4110 5120 4100 {}
N 5680 3970 5680 3790 {}
N 5790 4110 5790 4100 {}
N 5820 4050 5820 3970 {}
N 5830 4100 5830 4050 {}
N 5870 4110 5870 4100 {}
N 6050 4110 6050 4100 {}
N 6090 4100 6090 3810 {}
N 6130 4110 6130 4100 {}
N 6750 4110 6750 4100 {}
N 6750 4100 6750 4080 {}
N 6750 4080 6750 4030 {}
N 6760 4110 6760 4100 {}
N 6820 4070 6820 4030 {}
N 6830 4080 6830 4070 {}
N 6840 4110 6840 4090 {}
N 6840 4090 6840 4080 {}
N 6850 4090 6850 4080 {}
N 6860 4080 6860 4030 {}
N 6980 3930 6980 3770 {}
N 7060 4110 7060 4100 {}
N 7100 4100 7100 3930 {}
N 7140 4110 7140 4100 {}
N 7680 3970 7680 3790 {}
N 7790 4110 7790 4100 {}
N 7830 4100 7830 3970 {}
N 7870 4110 7870 4100 {}
N 9200 4110 9200 4100 {}
N 9240 4100 9240 3630 {}
N 9280 4110 9280 4100 {}
N 10860 4110 10860 4100 {}
N 10900 4100 10900 3350 {}
N 10940 4110 10940 4100 {}
N 11720 3610 11720 3350 {}
N 11850 4110 11850 4100 {}
N 11880 4050 11880 3750 {}
N 11880 3690 11880 3610 {}
N 11890 4100 11890 4050 {}
N 11890 3750 11890 3690 {}
N 11930 4110 11930 4100 {}
N 12300 4110 12300 4100 {}
N 12340 4100 12340 3330 {}
N 12380 4110 12380 4100 {}
N 13380 3600 13380 3350 {}
N 13520 4110 13520 4100 {}
N 13560 4100 13560 3600 {}
N 13600 4110 13600 4100 {}
N 14860 4110 14860 4100 {}
N 14900 4100 14900 3610 {}
N 14940 4110 14940 4100 {}
N 16520 4110 16520 4100 {}
N 16560 4100 16560 3330 {}
N 16600 4110 16600 4100 {}
N 17380 3590 17380 3310 {}
N 17500 4110 17500 4100 {}
N 17540 4100 17540 3590 {}
N 17580 4110 17580 4100 {}
N 17960 4110 17960 4100 {}
N 17990 4050 17990 3740 {}
N 17990 3720 17990 3310 {}
N 18000 4100 18000 4050 {}
N 18000 3740 18000 3720 {}
N 18040 4110 18040 4100 {}
N 19040 3580 19040 3310 {}
N 19190 4110 19190 4100 {}
N 19220 4050 19220 3580 {}
N 19230 4100 19230 4050 {}
N 19270 4110 19270 4100 {}
N 19510 4110 19510 4100 {}
N 14900 3550 14920 3550 {}
N 14320 2900 14900 2900 {}
N 14900 2900 15480 2900 {}
N 14310 2890 14320 2890 {}
N 14300 2880 14310 2880 {}
N 14100 2470 14300 2470 {}
N 15480 2230 15660 2230 {}
N 14100 2470 14100 2230 {}
N 14300 2880 14300 2470 {}
N 14310 2890 14310 2880 {}
N 14320 2900 14320 2890 {}
N 14900 3550 14900 2900 {}
N 15480 2900 15480 2230 {}
N 16780 3300 17050 3300 {}
N 17070 3300 17120 3300 {}
N 17050 3290 17070 3290 {}
N 17120 3280 17340 3280 {}
N 16560 3270 16740 3270 {}
N 16560 2870 16590 2870 {}
N 17030 2870 17050 2870 {}
N 16590 2860 17030 2860 {}
N 16400 1650 16560 1650 {}
N 16400 1650 16400 1390 {}
N 16560 3270 16560 2870 {}
N 16560 2870 16560 1650 {}
N 16590 2870 16590 2860 {}
N 17030 2870 17030 2860 {}
N 17050 3300 17050 3290 {}
N 17050 3290 17050 2870 {}
N 17070 3300 17070 3290 {}
N 17120 3300 17120 3280 {}
N 15480 2170 15660 2170 {}
N 15480 1830 16000 1830 {}
N 16000 1410 16010 1410 {}
N 15480 1390 15620 1390 {}
N 15660 1370 16010 1370 {}
N 16010 1370 16150 1370 {}
N 16150 1360 16360 1360 {}
N 15480 2170 15480 1830 {}
N 15480 1830 15480 1390 {}
N 15660 1370 15660 1360 {}
N 16000 1830 16000 1410 {}
N 16010 1410 16010 1370 {}
N 16150 1370 16150 1360 {}
N 9820 2170 10020 2170 {}
N 9820 1890 9830 1890 {}
N 9830 1850 9990 1850 {}
N 9820 1840 9830 1840 {}
N 9990 1840 10350 1840 {}
N 9820 1390 9960 1390 {}
N 10000 1390 10350 1390 {}
N 10350 1390 10490 1390 {}
N 10490 1380 10720 1380 {}
N 9820 2170 9820 1890 {}
N 9820 1840 9820 1390 {}
N 9830 1890 9830 1850 {}
N 9830 1850 9830 1840 {}
N 9990 1850 9990 1840 {}
N 10000 1390 10000 1360 {}
N 10350 1840 10350 1390 {}
N 10490 1390 10490 1380 {}
N 2640 3540 2780 3540 {}
N 2780 3090 2790 3090 {}
N 2790 3070 3290 3070 {}
N 2780 3050 2790 3050 {}
N 3290 3010 3300 3010 {}
N 3290 2950 3300 2950 {}
N 3290 2740 3300 2740 {}
N 2780 2730 2940 2730 {}
N 3290 2720 3300 2720 {}
N 3300 2720 3320 2720 {}
N 2980 2710 3290 2710 {}
N 3320 2710 3450 2710 {}
N 3820 2710 4070 2710 {}
N 3450 2700 3820 2700 {}
N 4070 2680 4260 2680 {}
N 2640 3730 2640 3540 {}
N 2780 3540 2780 3090 {}
N 2780 3050 2780 2730 {}
N 2790 3090 2790 3070 {}
N 2790 3070 2790 3050 {}
N 2980 2710 2980 2700 {}
N 3290 3070 3290 3010 {}
N 3290 2950 3290 2740 {}
N 3290 2720 3290 2710 {}
N 3300 3010 3300 2950 {}
N 3300 2740 3300 2720 {}
N 3320 2720 3320 2710 {}
N 3450 2710 3450 2700 {}
N 3820 2710 3820 2700 {}
N 4070 2710 4070 2680 {}
N 2780 2670 2940 2670 {}
N 2770 2250 2780 2250 {}
N 2390 2210 2400 2210 {}
N 2460 2210 2770 2210 {}
N 2400 2200 2410 2200 {}
N 2450 2200 2460 2200 {}
N 2410 2170 2420 2170 {}
N 2420 2160 2430 2160 {}
N 2770 2160 2780 2160 {}
N 2410 2150 2420 2150 {}
N 2430 2150 2450 2150 {}
N 2780 2030 2790 2030 {}
N 2780 2020 2790 2020 {}
N 2780 1730 2940 1730 {}
N 2390 2220 2390 2210 {}
N 2400 2210 2400 2200 {}
N 2410 2200 2410 2170 {}
N 2420 2170 2420 2160 {}
N 2420 2160 2420 2150 {}
N 2430 2160 2430 2150 {}
N 2450 2200 2450 2150 {}
N 2460 2210 2460 2200 {}
N 2770 2250 2770 2210 {}
N 2770 2210 2770 2160 {}
N 2780 2670 2780 2250 {}
N 2780 2160 2780 2030 {}
N 2780 2020 2780 1730 {}
N 2790 2030 2790 2020 {}
N 11120 3320 11390 3320 {}
N 11390 3320 11680 3320 {}
N 10900 3290 11080 3290 {}
N 10880 2900 10900 2900 {}
N 10900 2890 10940 2890 {}
N 11380 2890 11390 2890 {}
N 10940 2880 11380 2880 {}
N 10760 1660 10900 1660 {}
N 10760 1660 10760 1410 {}
N 10900 3290 10900 2900 {}
N 10900 2900 10900 2890 {}
N 10900 2890 10900 1660 {}
N 10940 2890 10940 2880 {}
N 11380 2890 11380 2880 {}
N 11390 3320 11390 2890 {}
N 8660 2920 9240 2920 {}
N 9240 2920 9820 2920 {}
N 8650 2910 8660 2910 {}
N 8640 2900 8650 2900 {}
N 8630 2890 8640 2890 {}
N 8460 2490 8630 2490 {}
N 9820 2230 10020 2230 {}
N 8460 2490 8460 2230 {}
N 8630 2890 8630 2490 {}
N 8640 2900 8640 2890 {}
N 8650 2910 8650 2900 {}
N 8660 2920 8660 2910 {}
N 9240 3570 9240 2920 {}
N 9820 2920 9820 2230 {}
N 4300 2470 4450 2470 {}
N 4450 2320 4460 2320 {}
N 4450 2260 4460 2260 {}
N 4170 2230 4210 2230 {}
N 4440 2230 4450 2230 {}
N 4160 2220 4170 2220 {}
N 4250 2210 4400 2210 {}
N 3960 2200 4160 2200 {}
N 4200 2200 4210 2200 {}
N 4210 2200 4250 2200 {}
N 4400 2200 4440 2200 {}
N 4190 2190 4200 2190 {}
N 4160 2180 4190 2180 {}
N 4440 2150 4450 2150 {}
N 4300 1910 4450 1910 {}
N 4160 2220 4160 2200 {}
N 4160 2200 4160 2180 {}
N 4170 2230 4170 2220 {}
N 4190 2190 4190 2180 {}
N 4200 2200 4200 2190 {}
N 4210 2230 4210 2200 {}
N 4250 2210 4250 2200 {}
N 4300 2650 4300 2470 {}
N 4300 1910 4300 1750 {}
N 4400 2210 4400 2200 {}
N 4440 2230 4440 2200 {}
N 4440 2200 4440 2150 {}
N 4450 2470 4450 2320 {}
N 4450 2260 4450 2230 {}
N 4450 2150 4450 1910 {}
N 4460 2320 4460 2260 {}
N 6920 3790 7000 3790 {}
N 6280 3770 6300 3770 {}
N 6300 3770 6570 3770 {}
N 6570 3770 6730 3770 {}
N 7000 3770 7450 3770 {}
N 7450 3760 7640 3760 {}
N 6730 3740 6920 3740 {}
N 6920 3740 6940 3740 {}
N 6240 3730 6300 3730 {}
N 6560 3500 6570 3500 {}
N 6100 3470 6560 3470 {}
N 6090 3080 6100 3080 {}
N 4470 3070 6090 3070 {}
N 4460 3060 4470 3060 {}
N 4450 2920 4460 2920 {}
N 4300 2900 4450 2900 {}
N 4300 2900 4300 2710 {}
N 4450 2920 4450 2900 {}
N 4460 3060 4460 2920 {}
N 4470 3070 4470 3060 {}
N 6090 3080 6090 3070 {}
N 6100 3470 6100 3080 {}
N 6240 3750 6240 3730 {}
N 6240 3730 6240 3720 {}
N 6280 3780 6280 3770 {}
N 6300 3770 6300 3730 {}
N 6560 3500 6560 3470 {}
N 6570 3770 6570 3500 {}
N 6730 3770 6730 3740 {}
N 6920 3790 6920 3740 {}
N 7000 3790 7000 3770 {}
N 7450 3770 7450 3760 {}
N 8460 1920 8630 1920 {}
N 8630 1300 9220 1300 {}
N 8630 830 8820 830 {}
N 8860 810 9220 810 {}
N 9220 810 11480 810 {}
N 11480 780 11680 780 {}
N 8460 2170 8460 1920 {}
N 8630 1920 8630 1300 {}
N 8630 1300 8630 830 {}
N 8860 810 8860 800 {}
N 9220 1300 9220 810 {}
N 11480 810 11480 780 {}
N 17380 2970 17560 2970 {}
N 17560 2550 17570 2550 {}
N 17570 2530 17580 2530 {}
N 17580 2500 17590 2500 {}
N 17590 2480 17600 2480 {}
N 17600 2460 17610 2460 {}
N 17610 2430 17620 2430 {}
N 17620 2410 17630 2410 {}
N 17630 2380 17640 2380 {}
N 17640 2360 17650 2360 {}
N 17650 2330 17660 2330 {}
N 17660 2320 17670 2320 {}
N 17670 2290 17680 2290 {}
N 17680 2270 17690 2270 {}
N 17690 2240 17700 2240 {}
N 17700 2220 17710 2220 {}
N 17710 2200 17720 2200 {}
N 17720 2170 17730 2170 {}
N 17730 2150 17740 2150 {}
N 17740 2120 17750 2120 {}
N 17750 2000 17840 2000 {}
N 17840 1880 17850 1880 {}
N 17850 1860 17860 1860 {}
N 17860 1840 17870 1840 {}
N 17870 1810 17880 1810 {}
N 17880 1790 17890 1790 {}
N 17890 1770 17900 1770 {}
N 17900 1740 17910 1740 {}
N 17910 1720 17920 1720 {}
N 17920 1690 17930 1690 {}
N 17930 1670 17940 1670 {}
N 17940 1650 17950 1650 {}
N 17950 1620 17960 1620 {}
N 17960 1600 17970 1600 {}
N 17970 1570 17980 1570 {}
N 17980 1550 17990 1550 {}
N 17990 1250 18620 1250 {}
N 17990 830 18180 830 {}
N 18620 810 18630 810 {}
N 18780 800 19020 800 {}
N 18630 770 18720 770 {}
N 18220 760 18630 760 {}
N 18720 760 18780 760 {}
N 17380 3250 17380 2970 {}
N 17560 2970 17560 2550 {}
N 17570 2550 17570 2530 {}
N 17580 2530 17580 2500 {}
N 17590 2500 17590 2480 {}
N 17600 2480 17600 2460 {}
N 17610 2460 17610 2430 {}
N 17620 2430 17620 2410 {}
N 17630 2410 17630 2380 {}
N 17640 2380 17640 2360 {}
N 17650 2360 17650 2330 {}
N 17660 2330 17660 2320 {}
N 17670 2320 17670 2290 {}
N 17680 2290 17680 2270 {}
N 17690 2270 17690 2240 {}
N 17700 2240 17700 2220 {}
N 17710 2220 17710 2200 {}
N 17720 2200 17720 2170 {}
N 17730 2170 17730 2150 {}
N 17740 2150 17740 2120 {}
N 17750 2120 17750 2000 {}
N 17840 2000 17840 1880 {}
N 17850 1880 17850 1860 {}
N 17860 1860 17860 1840 {}
N 17870 1840 17870 1810 {}
N 17880 1810 17880 1790 {}
N 17890 1790 17890 1770 {}
N 17900 1770 17900 1740 {}
N 17910 1740 17910 1720 {}
N 17920 1720 17920 1690 {}
N 17930 1690 17930 1670 {}
N 17940 1670 17940 1650 {}
N 17950 1650 17950 1620 {}
N 17960 1620 17960 1600 {}
N 17970 1600 17970 1570 {}
N 17980 1570 17980 1550 {}
N 17990 1550 17990 1250 {}
N 17990 1250 17990 830 {}
N 18220 800 18220 760 {}
N 18620 1250 18620 810 {}
N 18630 810 18630 770 {}
N 18630 770 18630 760 {}
N 18720 770 18720 760 {}
N 18780 800 18780 760 {}
N 5040 3530 5080 3530 {}
N 5080 2260 5090 2260 {}
N 5090 2220 8210 2220 {}
N 8210 2200 8420 2200 {}
N 5080 2180 5090 2180 {}
N 5080 1880 5090 1880 {}
N 5090 1840 5280 1840 {}
N 5080 1800 5090 1800 {}
N 5040 900 5080 900 {}
N 5040 3730 5040 3530 {}
N 5040 900 5040 750 {}
N 5080 3530 5080 2260 {}
N 5080 2180 5080 1880 {}
N 5080 1800 5080 900 {}
N 5090 2260 5090 2220 {}
N 5090 2220 5090 2180 {}
N 5090 1880 5090 1840 {}
N 5090 1840 5090 1800 {}
N 8210 2220 8210 2200 {}
N 3760 1480 3820 1480 {}
N 3820 1050 4320 1050 {}
N 4320 1040 4330 1040 {}
N 3820 750 3980 750 {}
N 4710 720 5080 720 {}
N 5450 720 5640 720 {}
N 4290 700 4330 700 {}
N 4330 700 4370 700 {}
N 4020 690 4290 690 {}
N 4370 690 4710 690 {}
N 5080 690 5450 690 {}
N 3760 1670 3760 1480 {}
N 3820 1480 3820 1050 {}
N 3820 1050 3820 750 {}
N 4020 720 4020 690 {}
N 4290 700 4290 690 {}
N 4320 1050 4320 1040 {}
N 4330 1040 4330 700 {}
N 4370 700 4370 690 {}
N 4710 720 4710 690 {}
N 5080 720 5080 690 {}
N 5450 720 5450 690 {}
N 3780 2480 3820 2480 {}
N 3810 2250 3820 2250 {}
N 3560 2200 3810 2200 {}
N 3810 2160 3820 2160 {}
N 3760 1910 3820 1910 {}
N 3760 1910 3760 1730 {}
N 3780 2670 3780 2480 {}
N 3810 2250 3810 2200 {}
N 3810 2200 3810 2160 {}
N 3820 2480 3820 2250 {}
N 3820 2160 3820 1910 {}
N 4020 3760 4040 3760 {}
N 4040 3760 4280 3760 {}
N 4350 3760 5080 3760 {}
N 5080 3760 5640 3760 {}
N 4280 3750 4320 3750 {}
N 4320 3750 4350 3750 {}
N 3980 3730 4040 3730 {}
N 4320 3700 4330 3700 {}
N 3820 3530 3830 3530 {}
N 3820 3450 4330 3450 {}
N 3780 2920 3820 2920 {}
N 3780 2920 3780 2730 {}
N 3820 3530 3820 3450 {}
N 3820 3450 3820 2920 {}
N 3980 3750 3980 3730 {}
N 3980 3730 3980 3720 {}
N 4020 3780 4020 3760 {}
N 4040 3760 4040 3730 {}
N 4280 3760 4280 3750 {}
N 4320 3750 4320 3700 {}
N 4330 3700 4330 3450 {}
N 4350 3760 4350 3750 {}
N 6980 3530 7100 3530 {}
N 7100 3130 10240 3130 {}
N 10240 3120 10250 3120 {}
N 10250 3110 10270 3110 {}
N 10270 3100 10280 3100 {}
N 10280 3090 10290 3090 {}
N 10290 3080 10300 3080 {}
N 10300 3070 10320 3070 {}
N 10320 3060 10330 3060 {}
N 10330 3050 10340 3050 {}
N 10340 3040 10350 3040 {}
N 10350 3030 10370 3030 {}
N 10370 3020 10380 3020 {}
N 10380 3010 10390 3010 {}
N 10390 3000 10400 3000 {}
N 10400 2990 10420 2990 {}
N 10420 2980 10430 2980 {}
N 10430 2970 10440 2970 {}
N 10440 2960 10450 2960 {}
N 10450 2950 10470 2950 {}
N 10470 2940 10480 2940 {}
N 10480 2930 10490 2930 {}
N 10490 2920 10500 2920 {}
N 10500 2910 10510 2910 {}
N 10510 2900 10530 2900 {}
N 10530 2890 10540 2890 {}
N 10540 2880 10550 2880 {}
N 10550 2870 10560 2870 {}
N 10560 2860 10580 2860 {}
N 10580 2850 10590 2850 {}
N 10590 2840 10600 2840 {}
N 10600 2830 10610 2830 {}
N 10610 2820 10630 2820 {}
N 10630 2810 10640 2810 {}
N 10640 2800 10650 2800 {}
N 10650 2790 10660 2790 {}
N 10660 2780 10680 2780 {}
N 10680 2770 10690 2770 {}
N 10690 2760 10700 2760 {}
N 10700 2750 10710 2750 {}
N 10710 2740 10730 2740 {}
N 10730 2730 10740 2730 {}
N 10740 2720 10750 2720 {}
N 10750 2710 10760 2710 {}
N 10760 2700 10770 2700 {}
N 10770 2690 10790 2690 {}
N 10790 2680 10800 2680 {}
N 10800 2670 10810 2670 {}
N 10810 2660 10820 2660 {}
N 10820 2650 10840 2650 {}
N 10840 2640 10850 2640 {}
N 10850 2590 10950 2590 {}
N 10950 2550 10960 2550 {}
N 10960 2540 10970 2540 {}
N 10970 2530 10980 2530 {}
N 10980 2520 11000 2520 {}
N 11000 2510 11010 2510 {}
N 11010 2500 11030 2500 {}
N 11030 2490 11040 2490 {}
N 11040 2480 11050 2480 {}
N 11050 2470 11060 2470 {}
N 11060 2460 11070 2460 {}
N 11070 2450 11090 2450 {}
N 11090 2440 11100 2440 {}
N 11100 2430 11110 2430 {}
N 11110 2420 11120 2420 {}
N 11120 2410 11130 2410 {}
N 11130 2400 11150 2400 {}
N 11150 2390 11160 2390 {}
N 11160 2380 11170 2380 {}
N 11170 2370 11190 2370 {}
N 11190 2360 11200 2360 {}
N 11200 2350 11210 2350 {}
N 11210 2340 11220 2340 {}
N 11220 2330 11240 2330 {}
N 11240 2320 11250 2320 {}
N 11250 2310 11260 2310 {}
N 11260 2300 11270 2300 {}
N 11270 2290 11280 2290 {}
N 11280 2280 11290 2280 {}
N 11290 2270 11310 2270 {}
N 11310 2260 11320 2260 {}
N 11320 2250 11330 2250 {}
N 11330 2240 11340 2240 {}
N 11340 2230 11360 2230 {}
N 11360 2220 11370 2220 {}
N 11370 2210 11390 2210 {}
N 11390 2200 11420 2200 {}
N 13860 2200 14060 2200 {}
N 11420 2190 13860 2190 {}
N 7100 1840 7320 1840 {}
N 7060 900 7100 900 {}
N 6980 3710 6980 3530 {}
N 7060 900 7060 750 {}
N 7100 3530 7100 3130 {}
N 7100 3130 7100 1840 {}
N 7100 1840 7100 900 {}
N 10240 3130 10240 3120 {}
N 10250 3120 10250 3110 {}
N 10270 3110 10270 3100 {}
N 10280 3100 10280 3090 {}
N 10290 3090 10290 3080 {}
N 10300 3080 10300 3070 {}
N 10320 3070 10320 3060 {}
N 10330 3060 10330 3050 {}
N 10340 3050 10340 3040 {}
N 10350 3040 10350 3030 {}
N 10370 3030 10370 3020 {}
N 10380 3020 10380 3010 {}
N 10390 3010 10390 3000 {}
N 10400 3000 10400 2990 {}
N 10420 2990 10420 2980 {}
N 10430 2980 10430 2970 {}
N 10440 2970 10440 2960 {}
N 10450 2960 10450 2950 {}
N 10470 2950 10470 2940 {}
N 10480 2940 10480 2930 {}
N 10490 2930 10490 2920 {}
N 10500 2920 10500 2910 {}
N 10510 2910 10510 2900 {}
N 10530 2900 10530 2890 {}
N 10540 2890 10540 2880 {}
N 10550 2880 10550 2870 {}
N 10560 2870 10560 2860 {}
N 10580 2860 10580 2850 {}
N 10590 2850 10590 2840 {}
N 10600 2840 10600 2830 {}
N 10610 2830 10610 2820 {}
N 10630 2820 10630 2810 {}
N 10640 2810 10640 2800 {}
N 10650 2800 10650 2790 {}
N 10660 2790 10660 2780 {}
N 10680 2780 10680 2770 {}
N 10690 2770 10690 2760 {}
N 10700 2760 10700 2750 {}
N 10710 2750 10710 2740 {}
N 10730 2740 10730 2730 {}
N 10740 2730 10740 2720 {}
N 10750 2720 10750 2710 {}
N 10760 2710 10760 2700 {}
N 10770 2700 10770 2690 {}
N 10790 2690 10790 2680 {}
N 10800 2680 10800 2670 {}
N 10810 2670 10810 2660 {}
N 10820 2660 10820 2650 {}
N 10840 2650 10840 2640 {}
N 10850 2640 10850 2590 {}
N 10950 2590 10950 2550 {}
N 10960 2550 10960 2540 {}
N 10970 2540 10970 2530 {}
N 10980 2530 10980 2520 {}
N 11000 2520 11000 2510 {}
N 11010 2510 11010 2500 {}
N 11030 2500 11030 2490 {}
N 11040 2490 11040 2480 {}
N 11050 2480 11050 2470 {}
N 11060 2470 11060 2460 {}
N 11070 2460 11070 2450 {}
N 11090 2450 11090 2440 {}
N 11100 2440 11100 2430 {}
N 11110 2430 11110 2420 {}
N 11120 2420 11120 2410 {}
N 11130 2410 11130 2400 {}
N 11150 2400 11150 2390 {}
N 11160 2390 11160 2380 {}
N 11170 2380 11170 2370 {}
N 11190 2370 11190 2360 {}
N 11200 2360 11200 2350 {}
N 11210 2350 11210 2340 {}
N 11220 2340 11220 2330 {}
N 11240 2330 11240 2320 {}
N 11250 2320 11250 2310 {}
N 11260 2310 11260 2300 {}
N 11270 2300 11270 2290 {}
N 11280 2290 11280 2280 {}
N 11290 2280 11290 2270 {}
N 11310 2270 11310 2260 {}
N 11320 2260 11320 2250 {}
N 11330 2250 11330 2240 {}
N 11340 2240 11340 2230 {}
N 11360 2230 11360 2220 {}
N 11370 2220 11370 2210 {}
N 11390 2210 11390 2200 {}
N 11420 2200 11420 2190 {}
N 13860 2200 13860 2190 {}
N 5680 3530 5830 3530 {}
N 5830 1840 6040 1840 {}
N 5680 900 5830 900 {}
N 5680 3730 5680 3530 {}
N 5680 900 5680 750 {}
N 5830 3530 5830 1840 {}
N 5830 1840 5830 900 {}
N 880 3770 900 3770 {}
N 900 3770 1200 3770 {}
N 1200 3770 1380 3770 {}
N 1380 3760 1740 3760 {}
N 1740 3760 2600 3760 {}
N 840 3750 900 3750 {}
N 690 3530 700 3530 {}
N 690 3500 700 3500 {}
N 700 3450 1200 3450 {}
N 690 3400 700 3400 {}
N 690 3170 700 3170 {}
N 690 3530 690 3500 {}
N 690 3400 690 3170 {}
N 700 3500 700 3450 {}
N 700 3450 700 3400 {}
N 840 3770 840 3750 {}
N 840 3750 840 3740 {}
N 880 3800 880 3770 {}
N 900 3770 900 3750 {}
N 1200 3770 1200 3450 {}
N 1380 3770 1380 3760 {}
N 10930 4120 14870 4120 {}
N 10890 4110 10930 4110 {}
N 14870 4110 14910 4110 {}
N 14910 3630 14940 3630 {}
N 690 3110 700 3110 {}
N 400 2980 410 2980 {}
N 410 2980 430 2980 {}
N 340 2970 350 2970 {}
N 350 2970 360 2970 {}
N 370 2970 400 2970 {}
N 430 2970 470 2970 {}
N 350 2960 370 2960 {}
N 10870 2910 10890 2910 {}
N 14940 2910 15490 2910 {}
N 10440 2670 10450 2670 {}
N 10440 2650 10450 2650 {}
N 10450 2650 10490 2650 {}
N 10400 2640 10440 2640 {}
N 10490 2640 10510 2640 {}
N 10360 2630 10400 2630 {}
N 10510 2630 10550 2630 {}
N 410 2620 420 2620 {}
N 420 2600 430 2600 {}
N 680 2600 690 2600 {}
N 430 2590 680 2590 {}
N 16110 2520 16120 2520 {}
N 15490 2250 15720 2250 {}
N 10060 2220 10450 2220 {}
N 10450 2220 10870 2220 {}
N 15700 2200 15720 2200 {}
N 15720 2200 16110 2200 {}
N 350 2970 350 2960 {}
N 360 3000 360 2970 {}
N 370 2970 370 2960 {}
N 400 2980 400 2970 {}
N 410 2980 410 2620 {}
N 420 2620 420 2600 {}
N 430 2980 430 2970 {}
N 430 2600 430 2590 {}
N 470 2970 470 2960 {}
N 680 2600 680 2590 {}
N 690 3110 690 2600 {}
N 10060 2220 10060 2200 {}
N 10400 2640 10400 2630 {}
N 10440 2650 10440 2640 {}
N 10450 2670 10450 2650 {}
N 10450 2650 10450 2220 {}
N 10490 2650 10490 2640 {}
N 10510 2640 10510 2630 {}
N 10870 2910 10870 2220 {}
N 10890 4110 10890 2910 {}
N 10930 4120 10930 4110 {}
N 14870 4120 14870 4110 {}
N 14910 4110 14910 3630 {}
N 14940 3630 14940 2910 {}
N 15490 2910 15490 2250 {}
N 15720 2250 15720 2200 {}
N 16110 2520 16110 2200 {}
N 11720 3000 11910 3000 {}
N 11910 2550 11920 2550 {}
N 11920 2530 11930 2530 {}
N 11930 2500 11940 2500 {}
N 11940 2480 11950 2480 {}
N 11950 2450 11960 2450 {}
N 11960 2430 11970 2430 {}
N 11970 2410 11980 2410 {}
N 11980 2380 11990 2380 {}
N 11990 2360 12000 2360 {}
N 12000 2330 12010 2330 {}
N 12010 2310 12020 2310 {}
N 12020 2280 12030 2280 {}
N 12030 2270 12040 2270 {}
N 12040 2260 12060 2260 {}
N 12060 2140 12090 2140 {}
N 12090 2020 12180 2020 {}
N 12180 1910 12190 1910 {}
N 12190 1880 12200 1880 {}
N 12200 1860 12210 1860 {}
N 12210 1830 12220 1830 {}
N 12220 1810 12230 1810 {}
N 12230 1790 12240 1790 {}
N 12240 1770 12250 1770 {}
N 12250 1740 12260 1740 {}
N 12260 1720 12270 1720 {}
N 12270 1690 12280 1690 {}
N 12280 1670 12290 1670 {}
N 12290 1640 12300 1640 {}
N 12300 1620 12310 1620 {}
N 12310 1600 12320 1600 {}
N 12320 1570 12330 1570 {}
N 12330 1270 12960 1270 {}
N 12960 1260 12970 1260 {}
N 12330 850 12520 850 {}
N 12560 780 12970 780 {}
N 12970 780 13360 780 {}
N 11720 3290 11720 3000 {}
N 11910 3000 11910 2550 {}
N 11920 2550 11920 2530 {}
N 11930 2530 11930 2500 {}
N 11940 2500 11940 2480 {}
N 11950 2480 11950 2450 {}
N 11960 2450 11960 2430 {}
N 11970 2430 11970 2410 {}
N 11980 2410 11980 2380 {}
N 11990 2380 11990 2360 {}
N 12000 2360 12000 2330 {}
N 12010 2330 12010 2310 {}
N 12020 2310 12020 2280 {}
N 12030 2280 12030 2270 {}
N 12040 2270 12040 2260 {}
N 12060 2260 12060 2140 {}
N 12090 2140 12090 2020 {}
N 12180 2020 12180 1910 {}
N 12190 1910 12190 1880 {}
N 12200 1880 12200 1860 {}
N 12210 1860 12210 1830 {}
N 12220 1830 12220 1810 {}
N 12230 1810 12230 1790 {}
N 12240 1790 12240 1770 {}
N 12250 1770 12250 1740 {}
N 12260 1740 12260 1720 {}
N 12270 1720 12270 1690 {}
N 12280 1690 12280 1670 {}
N 12290 1670 12290 1640 {}
N 12300 1640 12300 1620 {}
N 12310 1620 12310 1600 {}
N 12320 1600 12320 1570 {}
N 12330 1570 12330 1270 {}
N 12330 1270 12330 850 {}
N 12560 820 12560 780 {}
N 12960 1270 12960 1260 {}
N 12970 1260 12970 780 {}
N 18240 3280 18580 3280 {}
N 18580 3280 19000 3280 {}
N 17990 3250 18200 3250 {}
N 17990 2910 18000 2910 {}
N 18570 2850 18580 2850 {}
N 18000 2840 18570 2840 {}
N 17990 2800 18000 2800 {}
N 17980 2490 17990 2490 {}
N 17970 2470 17980 2470 {}
N 17960 2440 17970 2440 {}
N 17950 2420 17960 2420 {}
N 17940 2400 17950 2400 {}
N 17930 2380 17940 2380 {}
N 17920 2360 17930 2360 {}
N 17910 2330 17920 2330 {}
N 17900 2310 17910 2310 {}
N 17890 2290 17900 2290 {}
N 17880 2270 17890 2270 {}
N 17870 2240 17880 2240 {}
N 17860 2230 17870 2230 {}
N 17850 2200 17860 2200 {}
N 17840 2180 17850 2180 {}
N 17830 2150 17840 2150 {}
N 17820 2140 17830 2140 {}
N 17760 2110 17820 2110 {}
N 17710 1890 17760 1890 {}
N 17700 1870 17710 1870 {}
N 17690 1850 17700 1850 {}
N 17680 1820 17690 1820 {}
N 17670 1810 17680 1810 {}
N 17660 1780 17670 1780 {}
N 17650 1760 17660 1760 {}
N 17640 1740 17650 1740 {}
N 17630 1720 17640 1720 {}
N 17620 1690 17630 1690 {}
N 17610 1680 17620 1680 {}
N 17600 1650 17610 1650 {}
N 17590 1630 17600 1630 {}
N 17580 1610 17590 1610 {}
N 17570 1590 17580 1590 {}
N 17560 1560 17570 1560 {}
N 17550 1530 17560 1530 {}
N 17380 1060 17550 1060 {}
N 17380 1060 17380 790 {}
N 17550 1530 17550 1060 {}
N 17560 1560 17560 1530 {}
N 17570 1590 17570 1560 {}
N 17580 1610 17580 1590 {}
N 17590 1630 17590 1610 {}
N 17600 1650 17600 1630 {}
N 17610 1680 17610 1650 {}
N 17620 1690 17620 1680 {}
N 17630 1720 17630 1690 {}
N 17640 1740 17640 1720 {}
N 17650 1760 17650 1740 {}
N 17660 1780 17660 1760 {}
N 17670 1810 17670 1780 {}
N 17680 1820 17680 1810 {}
N 17690 1850 17690 1820 {}
N 17700 1870 17700 1850 {}
N 17710 1890 17710 1870 {}
N 17760 2110 17760 1890 {}
N 17820 2140 17820 2110 {}
N 17830 2150 17830 2140 {}
N 17840 2180 17840 2150 {}
N 17850 2200 17850 2180 {}
N 17860 2230 17860 2200 {}
N 17870 2240 17870 2230 {}
N 17880 2270 17880 2240 {}
N 17890 2290 17890 2270 {}
N 17900 2310 17900 2290 {}
N 17910 2330 17910 2310 {}
N 17920 2360 17920 2330 {}
N 17930 2380 17930 2360 {}
N 17940 2400 17940 2380 {}
N 17950 2420 17950 2400 {}
N 17960 2440 17960 2420 {}
N 17970 2470 17970 2440 {}
N 17980 2490 17980 2470 {}
N 17990 3250 17990 2910 {}
N 17990 2800 17990 2490 {}
N 18000 2910 18000 2840 {}
N 18000 2840 18000 2800 {}
N 18570 2850 18570 2840 {}
N 18580 3280 18580 2850 {}
N 9820 1330 9960 1330 {}
N 15470 1330 15620 1330 {}
N 10760 1080 10900 1080 {}
N 16400 1050 16560 1050 {}
N 15470 1010 15480 1010 {}
N 8630 770 8820 770 {}
N 14300 750 14460 750 {}
N 15470 660 15480 660 {}
N 1750 650 1900 650 {}
N 15470 500 15480 500 {}
N 9660 480 9820 480 {}
N 11720 480 11890 480 {}
N 13400 480 13580 480 {}
N 17380 470 17540 470 {}
N 3820 460 3830 460 {}
N 5040 460 5080 460 {}
N 5080 460 5090 460 {}
N 5830 460 5840 460 {}
N 6100 460 6110 460 {}
N 7060 460 7100 460 {}
N 7830 460 7840 460 {}
N 15330 460 15480 460 {}
N 19240 460 19250 460 {}
N 10900 450 10910 450 {}
N 16560 450 16570 450 {}
N 17990 450 18000 450 {}
N 7830 430 7840 430 {}
N 5080 420 5090 420 {}
N 19240 420 19250 420 {}
N 1750 400 1760 400 {}
N 1760 390 1770 390 {}
N 1770 380 1780 380 {}
N 2750 380 2830 380 {}
N 3780 380 3820 380 {}
N 3820 380 3860 380 {}
N 5050 380 5090 380 {}
N 5090 380 5130 380 {}
N 5790 380 5830 380 {}
N 5830 380 5870 380 {}
N 6060 380 6100 380 {}
N 6100 380 6140 380 {}
N 7800 380 7840 380 {}
N 7840 380 7880 380 {}
N 10760 380 10770 380 {}
N 12290 380 12330 380 {}
N 12330 380 12370 380 {}
N 14260 380 14300 380 {}
N 14300 380 14340 380 {}
N 16410 380 16420 380 {}
N 19210 380 19250 380 {}
N 19250 380 19290 380 {}
N 1780 370 2660 370 {}
N 2660 370 2750 370 {}
N 2830 370 3780 370 {}
N 3860 370 3980 370 {}
N 3980 370 5050 370 {}
N 5130 370 5680 370 {}
N 5680 370 5790 370 {}
N 5870 370 6060 370 {}
N 6140 370 6260 370 {}
N 6260 370 7100 370 {}
N 7100 370 7680 370 {}
N 7680 370 7800 370 {}
N 7880 370 8630 370 {}
N 8630 370 9660 370 {}
N 9820 370 10760 370 {}
N 10770 370 10910 370 {}
N 10910 370 11050 370 {}
N 11060 370 11890 370 {}
N 11890 370 12290 370 {}
N 12370 370 12520 370 {}
N 12520 370 13580 370 {}
N 13580 370 14260 370 {}
N 14340 370 15330 370 {}
N 15480 370 16410 370 {}
N 16420 370 16570 370 {}
N 16570 370 17540 370 {}
N 17540 370 17990 370 {}
N 17990 370 18180 370 {}
N 18180 370 19060 370 {}
N 19060 370 19210 370 {}
N 19290 370 19530 370 {}
N 19530 360 19540 360 {}
N 1750 650 1750 400 {}
N 1760 400 1760 390 {}
N 1770 390 1770 380 {}
N 1780 380 1780 370 {}
N 2660 690 2660 370 {}
N 2750 380 2750 370 {}
N 2830 380 2830 370 {}
N 3780 380 3780 370 {}
N 3820 460 3820 380 {}
N 3860 380 3860 370 {}
N 3980 690 3980 370 {}
N 5040 690 5040 460 {}
N 5050 380 5050 370 {}
N 5080 460 5080 420 {}
N 5090 420 5090 380 {}
N 5130 380 5130 370 {}
N 5680 690 5680 370 {}
N 5790 380 5790 370 {}
N 5830 460 5830 380 {}
N 5870 380 5870 370 {}
N 6060 380 6060 370 {}
N 6100 460 6100 380 {}
N 6140 380 6140 370 {}
N 6260 650 6260 370 {}
N 7060 690 7060 460 {}
N 7100 460 7100 370 {}
N 7680 690 7680 370 {}
N 7800 380 7800 370 {}
N 7830 460 7830 430 {}
N 7840 430 7840 380 {}
N 7880 380 7880 370 {}
N 8630 770 8630 370 {}
N 9660 480 9660 370 {}
N 9820 1330 9820 480 {}
N 9820 480 9820 370 {}
N 10760 1350 10760 1080 {}
N 10760 380 10760 370 {}
N 10770 380 10770 370 {}
N 10900 1080 10900 450 {}
N 10910 450 10910 370 {}
N 11720 750 11720 480 {}
N 11890 480 11890 370 {}
N 12290 380 12290 370 {}
N 12330 470 12330 380 {}
N 12370 380 12370 370 {}
N 12520 790 12520 370 {}
N 13400 750 13400 480 {}
N 13580 480 13580 370 {}
N 14260 380 14260 370 {}
N 14300 750 14300 380 {}
N 14340 380 14340 370 {}
N 15330 460 15330 370 {}
N 15470 1330 15470 1010 {}
N 15470 660 15470 500 {}
N 15480 1010 15480 660 {}
N 15480 500 15480 460 {}
N 15480 460 15480 370 {}
N 16400 1330 16400 1050 {}
N 16410 380 16410 370 {}
N 16420 380 16420 370 {}
N 16560 1050 16560 450 {}
N 16570 450 16570 370 {}
N 17380 730 17380 470 {}
N 17540 470 17540 370 {}
N 17990 450 17990 370 {}
N 18180 770 18180 370 {}
N 19060 770 19060 370 {}
N 19210 380 19210 370 {}
N 19240 460 19240 420 {}
N 19250 420 19250 380 {}
N 19290 380 19290 370 {}
N 19530 370 19530 360 {}
N 14100 1900 14300 1900 {}
N 14300 1280 14880 1280 {}
N 14300 810 14460 810 {}
N 14500 790 14880 790 {}
N 14880 790 17130 790 {}
N 17130 760 17340 760 {}
N 14100 2170 14100 1900 {}
N 14300 1900 14300 1280 {}
N 14300 1280 14300 810 {}
N 14500 790 14500 780 {}
N 14880 1280 14880 790 {}
N 17130 790 17130 760 {}
N 13380 3010 13580 3010 {}
N 13580 1820 13940 1820 {}
N 13920 1800 13940 1800 {}
N 13940 1800 13950 1800 {}
N 13400 1070 13580 1070 {}
N 13380 3290 13380 3010 {}
N 13400 1070 13400 810 {}
N 13580 3010 13580 1820 {}
N 13580 1820 13580 1070 {}
N 13940 1820 13940 1800 {}
N 7680 3520 7830 3520 {}
N 7830 1890 7840 1890 {}
N 7840 1840 8040 1840 {}
N 7830 1800 7840 1800 {}
N 7680 900 7830 900 {}
N 7680 3730 7680 3520 {}
N 7680 900 7680 750 {}
N 7830 3520 7830 1890 {}
N 7830 1800 7830 900 {}
N 7840 1890 7840 1840 {}
N 7840 1840 7840 1800 {}
N 8040 1840 8040 1820 {}
N 4300 1060 4330 1060 {}
N 4330 1050 4340 1050 {}
N 4340 1000 6080 1000 {}
N 6080 1000 6530 1000 {}
N 6530 990 6540 990 {}
N 6080 910 6090 910 {}
N 6260 730 6320 730 {}
N 6730 720 7100 720 {}
N 7450 720 7640 720 {}
N 6530 700 6540 700 {}
N 6540 700 6560 700 {}
N 6300 690 6320 690 {}
N 6320 690 6530 690 {}
N 6560 690 6730 690 {}
N 7100 690 7450 690 {}
N 4300 1690 4300 1060 {}
N 4330 1060 4330 1050 {}
N 4340 1050 4340 1000 {}
N 6080 1000 6080 910 {}
N 6260 740 6260 730 {}
N 6260 730 6260 710 {}
N 6300 690 6300 680 {}
N 6320 730 6320 690 {}
N 6530 1000 6530 990 {}
N 6530 700 6530 690 {}
N 6540 990 6540 700 {}
N 6560 700 6560 690 {}
N 6730 720 6730 690 {}
N 7100 720 7100 690 {}
N 7450 720 7450 690 {}
N 19040 2980 19240 2980 {}
N 19240 1770 19250 1770 {}
N 19250 1730 19440 1730 {}
N 19240 1680 19250 1680 {}
N 19060 1050 19240 1050 {}
N 19040 3250 19040 2980 {}
N 19060 1050 19060 830 {}
N 19240 2980 19240 1770 {}
N 19240 1680 19240 1050 {}
N 19250 1770 19250 1730 {}
N 19250 1730 19250 1680 {}
N 19440 1730 19440 1720 {}
N 13100 3320 13340 3320 {}
N 12580 3300 12930 3300 {}
N 12930 3300 13100 3300 {}
N 12340 3270 12540 3270 {}
N 12340 2870 12380 2870 {}
N 12920 2870 12930 2870 {}
N 12380 2860 12920 2860 {}
N 12330 2530 12340 2530 {}
N 12320 2510 12330 2510 {}
N 12310 2480 12320 2480 {}
N 12300 2460 12310 2460 {}
N 12290 2440 12300 2440 {}
N 12280 2420 12290 2420 {}
N 12270 2390 12280 2390 {}
N 12260 2370 12270 2370 {}
N 12250 2350 12260 2350 {}
N 12240 2330 12250 2330 {}
N 12230 2310 12240 2310 {}
N 12220 2280 12230 2280 {}
N 12210 2260 12220 2260 {}
N 12180 2240 12210 2240 {}
N 12160 2140 12180 2140 {}
N 12100 2130 12160 2130 {}
N 12050 1910 12100 1910 {}
N 12040 1890 12050 1890 {}
N 12030 1870 12040 1870 {}
N 12020 1850 12030 1850 {}
N 12010 1820 12020 1820 {}
N 12000 1800 12010 1800 {}
N 11990 1780 12000 1780 {}
N 11980 1760 11990 1760 {}
N 11970 1730 11980 1730 {}
N 11960 1710 11970 1710 {}
N 11950 1690 11960 1690 {}
N 11940 1670 11950 1670 {}
N 11930 1650 11940 1650 {}
N 11920 1620 11930 1620 {}
N 11910 1600 11920 1600 {}
N 11900 1580 11910 1580 {}
N 11890 1550 11900 1550 {}
N 11720 1080 11890 1080 {}
N 11720 1080 11720 810 {}
N 11890 1550 11890 1080 {}
N 11900 1580 11900 1550 {}
N 11910 1600 11910 1580 {}
N 11920 1620 11920 1600 {}
N 11930 1650 11930 1620 {}
N 11940 1670 11940 1650 {}
N 11950 1690 11950 1670 {}
N 11960 1710 11960 1690 {}
N 11970 1730 11970 1710 {}
N 11980 1760 11980 1730 {}
N 11990 1780 11990 1760 {}
N 12000 1800 12000 1780 {}
N 12010 1820 12010 1800 {}
N 12020 1850 12020 1820 {}
N 12030 1870 12030 1850 {}
N 12040 1890 12040 1870 {}
N 12050 1910 12050 1890 {}
N 12100 2130 12100 1910 {}
N 12160 2140 12160 2130 {}
N 12180 2240 12180 2140 {}
N 12210 2260 12210 2240 {}
N 12220 2280 12220 2260 {}
N 12230 2310 12230 2280 {}
N 12240 2330 12240 2310 {}
N 12250 2350 12250 2330 {}
N 12260 2370 12260 2350 {}
N 12270 2390 12270 2370 {}
N 12280 2420 12280 2390 {}
N 12290 2440 12290 2420 {}
N 12300 2460 12300 2440 {}
N 12310 2480 12310 2460 {}
N 12320 2510 12320 2480 {}
N 12330 2530 12330 2510 {}
N 12340 3270 12340 2870 {}
N 12340 2870 12340 2530 {}
N 12380 2870 12380 2860 {}
N 12920 2870 12920 2860 {}
N 12930 3300 12930 2870 {}
N 13100 3320 13100 3300 {}
N 4080 1720 4260 1720 {}
N 2980 1710 3300 1710 {}
N 3300 1710 3450 1710 {}
N 3800 1710 4080 1710 {}
N 3450 1700 3800 1700 {}
N 2790 1670 2940 1670 {}
N 2790 1400 2820 1400 {}
N 3280 1400 3300 1400 {}
N 2820 1390 3280 1390 {}
N 2660 900 2790 900 {}
N 2660 900 2660 750 {}
N 2790 1670 2790 1400 {}
N 2790 1400 2790 900 {}
N 2820 1400 2820 1390 {}
N 2980 1710 2980 1700 {}
N 3280 1400 3280 1390 {}
N 3300 1710 3300 1400 {}
N 3450 1710 3450 1700 {}
N 3800 1710 3800 1700 {}
N 4080 1720 4080 1710 {}
N 1700 3520 1750 3520 {}
N 1750 1070 1760 1070 {}
N 1760 1050 2260 1050 {}
N 1750 1030 1760 1030 {}
N 2260 720 2270 720 {}
N 2420 720 2620 720 {}
N 1750 710 1900 710 {}
N 2250 700 2270 700 {}
N 2270 700 2290 700 {}
N 1940 690 2250 690 {}
N 2290 690 2420 690 {}
N 1700 3730 1700 3520 {}
N 1750 3520 1750 1070 {}
N 1750 1030 1750 710 {}
N 1760 1070 1760 1050 {}
N 1760 1050 1760 1030 {}
N 1940 690 1940 680 {}
N 2250 700 2250 690 {}
N 2260 1050 2260 720 {}
N 2270 720 2270 700 {}
N 2290 700 2290 690 {}
N 2420 720 2420 690 {}
