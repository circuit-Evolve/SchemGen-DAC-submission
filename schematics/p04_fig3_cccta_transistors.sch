v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 1680 700 2 0 {name="I_current_11_0" value=1m}
C {devices/isource.sym} 3420 700 2 0 {name="I_current_3_1" value=1m}
C {devices/gnd.sym} 1940 520 0 0 {name="l_gnd_52_2" lab="GND"}
C {devices/gnd.sym} 3680 520 0 0 {name="l_gnd_54_3" lab="GND"}
C {sky130_fd_pr/nfet3_01v8.sym} 540 380 0 1 {name="M_nmos_0_4"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3240 440 0 0 {name="M_nmos_10_5"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 220 380 0 0 {name="M_nmos_12_6"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3840 640 0 1 {name="M_nmos_16_7"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2560 640 0 0 {name="M_nmos_17_8"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4600 640 0 1 {name="M_nmos_19_9"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1300 680 0 0 {name="M_nmos_22_10"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3600 440 0 1 {name="M_nmos_23_11"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4740 640 0 0 {name="M_nmos_24_12"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1840 440 0 1 {name="M_nmos_28_13"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3060 640 0 0 {name="M_nmos_29_14"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4400 640 0 0 {name="M_nmos_30_15"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1500 440 0 0 {name="M_nmos_33_16"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2760 640 0 1 {name="M_nmos_7_17"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2080 640 0 1 {name="M_nmos_9_18"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2420 640 0 1 {name="M_nmos_cross_2_19"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1060 680 0 1 {name="M_nmos_cross_31_20"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 920 680 0 1 {name="M_nmos_cross_32_21"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4300 640 0 1 {name="M_nmos_cross_35_22"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 720 680 0 1 {name="M_nmos_cross_37_23"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 640 0 1 {name="M_nmos_cross_39_24"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2260 640 0 1 {name="M_nmos_cross_40_25"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 360 680 0 1 {name="M_nmos_cross_42_26"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 1200 680 0 1 {name="M_nmos_cross_47_27"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4000 640 0 1 {name="M_nmos_cross_49_28"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 2940 640 0 1 {name="M_nmos_cross_53_29"
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 440 160 0 0 {name="M_pmos_1_30"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1300 180 0 0 {name="M_pmos_13_31"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4600 180 0 1 {name="M_pmos_14_32"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1580 160 0 1 {name="M_pmos_15_33"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3740 280 0 0 {name="M_pmos_18_34"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3580 280 0 1 {name="M_pmos_20_35"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4740 180 0 0 {name="M_pmos_21_36"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1980 280 0 0 {name="M_pmos_25_37"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1840 280 0 1 {name="M_pmos_26_38"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 680 180 0 0 {name="M_pmos_27_39"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 300 160 0 1 {name="M_pmos_34_40"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 160 0 1 {name="M_pmos_36_41"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2760 180 0 1 {name="M_pmos_4_42"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2580 180 0 0 {name="M_pmos_5_43"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3060 180 0 0 {name="M_pmos_6_44"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4400 180 0 0 {name="M_pmos_8_45"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1060 160 0 1 {name="M_pmos_cross_38_46"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2380 160 0 0 {name="M_pmos_cross_41_47"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4000 160 0 1 {name="M_pmos_cross_43_48"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4300 160 0 1 {name="M_pmos_cross_44_49"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 920 160 0 1 {name="M_pmos_cross_45_50"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2220 160 0 0 {name="M_pmos_cross_46_51"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 160 0 1 {name="M_pmos_cross_48_52"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2960 160 0 1 {name="M_pmos_cross_50_53"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 1200 160 0 1 {name="M_pmos_cross_51_54"
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 240 680 0 0 {name="p_port_56_55" lab="PORT_refined_28"}
C {devices/ipin.sym} 4860 80 0 0 {name="p_port_64_56" lab="PORT_refined_3"}
N 4900 790 4910 790 {}
N 360 780 730 780 {}
N 730 780 920 780 {}
N 920 780 1060 780 {}
N 1060 780 1210 780 {}
N 1210 780 1360 780 {}
N 1360 780 1670 780 {}
N 1670 780 2030 780 {}
N 2030 780 2260 780 {}
N 2260 780 2410 780 {}
N 2410 780 2610 780 {}
N 2610 780 2700 780 {}
N 2700 780 2950 780 {}
N 2950 780 3100 780 {}
N 3100 780 3420 780 {}
N 3420 780 3780 780 {}
N 3780 780 3990 780 {}
N 3990 780 4150 780 {}
N 4150 780 4300 780 {}
N 4300 780 4450 780 {}
N 4450 780 4540 780 {}
N 4540 780 4790 780 {}
N 4790 780 4900 780 {}
N 4900 780 4910 780 {}
N 920 770 930 770 {}
N 4150 770 4160 770 {}
N 340 730 360 730 {}
N 700 730 730 730 {}
N 900 730 930 730 {}
N 1040 730 1060 730 {}
N 1180 730 1210 730 {}
N 1320 730 1360 730 {}
N 1670 730 1680 730 {}
N 4150 730 4160 730 {}
N 2240 700 2260 700 {}
N 2400 700 2410 700 {}
N 2580 700 2610 700 {}
N 2920 700 2950 700 {}
N 3080 700 3100 700 {}
N 3980 700 3990 700 {}
N 4140 700 4160 700 {}
N 4280 700 4300 700 {}
N 4420 700 4450 700 {}
N 4760 700 4790 700 {}
N 2030 670 2060 670 {}
N 2700 670 2740 670 {}
N 3780 670 3820 670 {}
N 4540 670 4580 670 {}
N 340 730 340 710 {}
N 360 780 360 730 {}
N 700 730 700 710 {}
N 730 780 730 730 {}
N 900 730 900 710 {}
N 920 780 920 770 {}
N 930 770 930 730 {}
N 1040 730 1040 710 {}
N 1060 780 1060 730 {}
N 1180 730 1180 710 {}
N 1210 780 1210 730 {}
N 1320 730 1320 710 {}
N 1360 780 1360 730 {}
N 1670 780 1670 730 {}
N 2030 780 2030 670 {}
N 2240 700 2240 670 {}
N 2260 780 2260 700 {}
N 2400 700 2400 670 {}
N 2410 780 2410 700 {}
N 2580 700 2580 670 {}
N 2610 780 2610 700 {}
N 2700 780 2700 670 {}
N 2920 700 2920 670 {}
N 2950 780 2950 700 {}
N 3080 700 3080 670 {}
N 3100 780 3100 700 {}
N 3420 780 3420 730 {}
N 3780 780 3780 670 {}
N 3980 700 3980 670 {}
N 3990 780 3990 700 {}
N 4140 700 4140 670 {}
N 4150 780 4150 770 {}
N 4160 770 4160 730 {}
N 4160 730 4160 700 {}
N 4280 700 4280 670 {}
N 4300 780 4300 700 {}
N 4420 700 4420 670 {}
N 4450 780 4450 700 {}
N 4540 780 4540 670 {}
N 4760 700 4760 670 {}
N 4790 780 4790 700 {}
N 4900 790 4900 780 {}
N 4910 790 4910 780 {}
N 1670 670 1680 670 {}
N 1540 560 1670 560 {}
N 1670 560 1800 560 {}
N 1520 490 1540 490 {}
N 1800 470 1820 470 {}
N 1520 490 1520 470 {}
N 1540 560 1540 490 {}
N 1670 670 1670 560 {}
N 1800 560 1800 470 {}
N 700 610 730 610 {}
N 560 380 730 380 {}
N 730 320 800 320 {}
N 700 220 730 220 {}
N 700 650 700 610 {}
N 700 220 700 210 {}
N 730 610 730 380 {}
N 730 380 730 320 {}
N 730 320 730 220 {}
N 240 320 250 320 {}
N 250 270 260 270 {}
N 260 270 600 270 {}
N 600 270 790 270 {}
N 250 260 260 260 {}
N 250 240 260 240 {}
N 250 190 280 190 {}
N 620 180 660 180 {}
N 1260 180 1280 180 {}
N 600 170 620 170 {}
N 790 170 820 170 {}
N 930 170 960 170 {}
N 1070 170 1110 170 {}
N 1220 170 1260 170 {}
N 820 160 930 160 {}
N 930 160 940 160 {}
N 960 160 1070 160 {}
N 1070 160 1080 160 {}
N 1110 160 1220 160 {}
N 240 350 240 320 {}
N 250 320 250 270 {}
N 250 240 250 190 {}
N 260 270 260 260 {}
N 260 260 260 240 {}
N 600 270 600 170 {}
N 620 180 620 170 {}
N 790 270 790 170 {}
N 820 170 820 160 {}
N 930 170 930 160 {}
N 960 170 960 160 {}
N 1070 170 1070 160 {}
N 1110 170 1110 160 {}
N 1220 170 1220 160 {}
N 1260 180 1260 170 {}
N 490 350 520 350 {}
N 370 240 490 240 {}
N 460 220 490 220 {}
N 320 170 370 170 {}
N 370 170 400 170 {}
N 400 160 420 160 {}
N 320 170 320 160 {}
N 370 240 370 170 {}
N 400 170 400 160 {}
N 460 220 460 190 {}
N 490 350 490 240 {}
N 490 240 490 220 {}
N 3260 380 3290 380 {}
N 3280 260 3290 260 {}
N 3290 260 3420 260 {}
N 3290 190 3320 190 {}
N 4360 180 4380 180 {}
N 3360 170 3420 170 {}
N 3420 170 3910 170 {}
N 4010 170 4070 170 {}
N 4160 170 4220 170 {}
N 4310 170 4360 170 {}
N 3910 160 4010 160 {}
N 4010 160 4020 160 {}
N 4070 160 4160 160 {}
N 4160 160 4180 160 {}
N 4220 160 4310 160 {}
N 4310 160 4320 160 {}
N 3260 410 3260 380 {}
N 3290 380 3290 260 {}
N 3290 260 3290 190 {}
N 3360 170 3360 160 {}
N 3420 260 3420 170 {}
N 3910 170 3910 160 {}
N 4010 170 4010 160 {}
N 4070 170 4070 160 {}
N 4160 170 4160 160 {}
N 4220 170 4220 160 {}
N 4310 170 4310 160 {}
N 4360 180 4360 170 {}
N 2580 580 2620 580 {}
N 2620 480 2630 480 {}
N 2630 460 2640 460 {}
N 2640 420 2660 420 {}
N 2660 380 2680 380 {}
N 2680 340 2690 340 {}
N 2690 330 2700 330 {}
N 2700 260 2830 260 {}
N 2700 210 2740 210 {}
N 3010 180 3040 180 {}
N 2780 160 2830 160 {}
N 2830 160 2980 160 {}
N 2980 160 3010 160 {}
N 2580 610 2580 580 {}
N 2620 580 2620 480 {}
N 2630 480 2630 460 {}
N 2640 460 2640 420 {}
N 2660 420 2660 380 {}
N 2680 380 2680 340 {}
N 2690 340 2690 330 {}
N 2700 330 2700 260 {}
N 2700 260 2700 210 {}
N 2780 180 2780 160 {}
N 2830 260 2830 160 {}
N 3010 180 3010 160 {}
N 2780 640 2820 640 {}
N 2820 640 2960 640 {}
N 2960 640 3040 640 {}
N 2700 610 2740 610 {}
N 2700 560 2820 560 {}
N 2690 470 2700 470 {}
N 2680 460 2690 460 {}
N 2670 420 2680 420 {}
N 2650 400 2670 400 {}
N 2640 380 2650 380 {}
N 2630 350 2640 350 {}
N 2620 330 2630 330 {}
N 2600 220 2620 220 {}
N 2600 220 2600 210 {}
N 2620 330 2620 220 {}
N 2630 350 2630 330 {}
N 2640 380 2640 350 {}
N 2650 400 2650 380 {}
N 2670 420 2670 400 {}
N 2680 460 2680 420 {}
N 2690 470 2690 460 {}
N 2700 610 2700 560 {}
N 2700 560 2700 470 {}
N 2820 640 2820 560 {}
N 1520 220 1560 220 {}
N 1560 210 1620 210 {}
N 2180 210 2260 210 {}
N 2340 210 2420 210 {}
N 2420 180 2560 180 {}
N 1600 160 1620 160 {}
N 1620 160 2180 160 {}
N 2180 160 2200 160 {}
N 2260 160 2340 160 {}
N 2340 160 2360 160 {}
N 1520 410 1520 220 {}
N 1560 220 1560 210 {}
N 1560 210 1560 190 {}
N 1620 210 1620 160 {}
N 2180 210 2180 160 {}
N 2260 210 2260 160 {}
N 2340 210 2340 160 {}
N 2420 210 2420 180 {}
N 3080 580 3100 580 {}
N 3100 340 3160 340 {}
N 3080 220 3100 220 {}
N 3080 610 3080 580 {}
N 3080 220 3080 210 {}
N 3100 580 3100 340 {}
N 3100 340 3100 220 {}
N 340 610 360 610 {}
N 260 510 360 510 {}
N 360 510 490 510 {}
N 250 500 260 500 {}
N 240 440 250 440 {}
N 490 410 520 410 {}
N 240 440 240 410 {}
N 250 500 250 440 {}
N 260 510 260 500 {}
N 340 650 340 610 {}
N 360 610 360 510 {}
N 490 510 490 410 {}
N 4620 640 4660 640 {}
N 4660 640 4720 640 {}
N 4540 610 4580 610 {}
N 4540 560 4660 560 {}
N 4530 480 4540 480 {}
N 4520 460 4530 460 {}
N 4510 440 4520 440 {}
N 4500 420 4510 420 {}
N 4480 380 4500 380 {}
N 4470 350 4480 350 {}
N 4460 340 4470 340 {}
N 4450 310 4460 310 {}
N 4420 220 4450 220 {}
N 4420 220 4420 210 {}
N 4450 310 4450 220 {}
N 4460 340 4460 310 {}
N 4470 350 4470 340 {}
N 4480 380 4480 350 {}
N 4500 420 4500 380 {}
N 4510 440 4510 420 {}
N 4520 460 4520 440 {}
N 4530 480 4530 460 {}
N 4540 610 4540 560 {}
N 4540 560 4540 480 {}
N 4660 640 4660 560 {}
N 3290 560 3420 560 {}
N 3420 560 3550 560 {}
N 3260 490 3290 490 {}
N 3550 470 3580 470 {}
N 3260 490 3260 470 {}
N 3290 560 3290 490 {}
N 3420 670 3420 560 {}
N 3550 560 3550 470 {}
N 1040 620 1060 620 {}
N 1040 220 1060 220 {}
N 1040 650 1040 620 {}
N 1040 220 1040 190 {}
N 1060 620 1060 220 {}
N 2400 580 2420 580 {}
N 2420 340 2470 340 {}
N 2400 220 2420 220 {}
N 2400 610 2400 580 {}
N 2400 220 2400 190 {}
N 2420 580 2420 340 {}
N 2420 340 2420 220 {}
N 3980 590 4000 590 {}
N 4000 360 4050 360 {}
N 3980 220 4000 220 {}
N 3980 610 3980 590 {}
N 3980 220 3980 190 {}
N 4000 590 4000 360 {}
N 4000 360 4000 220 {}
N 170 380 200 380 {}
N 4280 580 4300 580 {}
N 4300 360 4350 360 {}
N 4280 220 4300 220 {}
N 4280 610 4280 580 {}
N 4280 220 4280 190 {}
N 4300 580 4300 360 {}
N 4300 360 4300 220 {}
N 4140 580 4160 580 {}
N 4160 360 4210 360 {}
N 4140 220 4160 220 {}
N 4140 610 4140 580 {}
N 4140 220 4140 190 {}
N 4160 580 4160 360 {}
N 4160 360 4160 220 {}
N 2920 580 2960 580 {}
N 2960 340 3010 340 {}
N 2940 220 2960 220 {}
N 2920 610 2920 580 {}
N 2940 220 2940 190 {}
N 2960 580 2960 340 {}
N 2960 340 2960 220 {}
N 1180 620 1210 620 {}
N 1210 320 1270 320 {}
N 1180 220 1210 220 {}
N 1180 650 1180 620 {}
N 1180 220 1180 190 {}
N 1210 620 1210 320 {}
N 1210 320 1210 220 {}
N 280 680 370 680 {}
N 370 680 380 680 {}
N 620 680 740 680 {}
N 820 680 940 680 {}
N 960 680 1070 680 {}
N 1070 680 1080 680 {}
N 1110 680 1220 680 {}
N 1260 680 1280 680 {}
N 240 670 280 670 {}
N 370 670 620 670 {}
N 740 670 820 670 {}
N 940 670 960 670 {}
N 1070 670 1110 670 {}
N 1220 670 1260 670 {}
N 240 680 240 670 {}
N 280 680 280 670 {}
N 370 680 370 670 {}
N 620 680 620 670 {}
N 740 680 740 670 {}
N 820 680 820 670 {}
N 940 680 940 670 {}
N 960 680 960 670 {}
N 1070 680 1070 670 {}
N 1110 680 1110 670 {}
N 1220 680 1220 670 {}
N 1260 680 1260 670 {}
N 3860 640 3890 640 {}
N 3890 640 4020 640 {}
N 4020 640 4180 640 {}
N 4180 640 4320 640 {}
N 4320 640 4380 640 {}
N 3780 610 3820 610 {}
N 3780 570 3790 570 {}
N 3790 560 3890 560 {}
N 3780 550 3790 550 {}
N 3760 330 3780 330 {}
N 3760 330 3760 310 {}
N 3780 610 3780 570 {}
N 3780 570 3780 550 {}
N 3780 550 3780 330 {}
N 3790 570 3790 560 {}
N 3790 560 3790 550 {}
N 3890 640 3890 560 {}
N 1800 250 1820 250 {}
N 3550 250 3560 250 {}
N 2000 220 2030 220 {}
N 3760 220 3780 220 {}
N 3550 190 3780 190 {}
N 250 130 280 130 {}
N 3290 130 3320 130 {}
N 460 110 490 110 {}
N 900 110 930 110 {}
N 1040 110 1060 110 {}
N 1180 110 1210 110 {}
N 1540 110 1560 110 {}
N 2240 110 2260 110 {}
N 2400 110 2410 110 {}
N 2600 110 2610 110 {}
N 2940 110 2950 110 {}
N 2950 110 2960 110 {}
N 3080 110 3100 110 {}
N 3980 110 4000 110 {}
N 4140 110 4160 110 {}
N 4280 110 4300 110 {}
N 2030 100 2040 100 {}
N 4150 100 4160 100 {}
N 4540 100 4550 100 {}
N 4790 100 4800 100 {}
N 250 90 260 90 {}
N 2950 90 2960 90 {}
N 260 80 490 80 {}
N 490 80 700 80 {}
N 700 80 730 80 {}
N 730 80 930 80 {}
N 930 80 1060 80 {}
N 1060 80 1210 80 {}
N 1210 80 1320 80 {}
N 1320 80 1360 80 {}
N 1360 80 1540 80 {}
N 1540 80 1800 80 {}
N 1800 80 2040 80 {}
N 2040 80 2260 80 {}
N 2260 80 2410 80 {}
N 2410 80 2610 80 {}
N 2610 80 2740 80 {}
N 2740 80 2960 80 {}
N 2960 80 3100 80 {}
N 3100 80 3290 80 {}
N 3290 80 3780 80 {}
N 3780 80 4000 80 {}
N 4000 80 4160 80 {}
N 4160 80 4300 80 {}
N 4300 80 4420 80 {}
N 4420 80 4450 80 {}
N 4450 80 4540 80 {}
N 4540 80 4580 80 {}
N 4580 80 4760 80 {}
N 4760 80 4790 80 {}
N 4790 80 4860 80 {}
N 250 130 250 90 {}
N 260 90 260 80 {}
N 460 130 460 110 {}
N 490 110 490 80 {}
N 700 150 700 80 {}
N 730 110 730 80 {}
N 900 130 900 110 {}
N 930 110 930 80 {}
N 1040 130 1040 110 {}
N 1060 110 1060 80 {}
N 1180 130 1180 110 {}
N 1210 110 1210 80 {}
N 1320 150 1320 80 {}
N 1360 110 1360 80 {}
N 1540 110 1540 80 {}
N 1560 130 1560 110 {}
N 1560 110 1560 100 {}
N 1800 250 1800 80 {}
N 2000 250 2000 220 {}
N 2030 220 2030 100 {}
N 2040 100 2040 80 {}
N 2240 130 2240 110 {}
N 2260 110 2260 80 {}
N 2400 130 2400 110 {}
N 2410 110 2410 80 {}
N 2600 150 2600 110 {}
N 2610 110 2610 80 {}
N 2740 150 2740 80 {}
N 2940 130 2940 110 {}
N 2950 110 2950 90 {}
N 2960 110 2960 100 {}
N 2960 90 2960 80 {}
N 3080 150 3080 110 {}
N 3100 110 3100 80 {}
N 3290 130 3290 80 {}
N 3550 250 3550 190 {}
N 3760 250 3760 220 {}
N 3780 220 3780 190 {}
N 3780 190 3780 80 {}
N 3980 130 3980 110 {}
N 4000 110 4000 80 {}
N 4140 130 4140 110 {}
N 4160 110 4160 100 {}
N 4160 100 4160 80 {}
N 4280 130 4280 110 {}
N 4300 110 4300 80 {}
N 4420 150 4420 80 {}
N 4450 110 4450 80 {}
N 4540 100 4540 80 {}
N 4580 150 4580 80 {}
N 4760 150 4760 80 {}
N 4790 100 4790 80 {}
N 1320 620 1360 620 {}
N 1360 320 1410 320 {}
N 1320 220 1360 220 {}
N 1320 650 1320 620 {}
N 1320 220 1320 210 {}
N 1360 620 1360 320 {}
N 1360 320 1360 220 {}
N 1860 440 1940 440 {}
N 3620 440 3680 440 {}
N 1940 520 1940 440 {}
N 3680 520 3680 440 {}
N 900 440 1480 440 {}
N 900 650 900 440 {}
N 900 440 900 190 {}
N 3550 410 3580 410 {}
N 3550 360 3660 360 {}
N 3550 310 3560 310 {}
N 3600 280 3660 280 {}
N 3660 280 3720 280 {}
N 3550 410 3550 360 {}
N 3550 360 3550 310 {}
N 3660 360 3660 280 {}
N 4760 580 4790 580 {}
N 4790 390 4850 390 {}
N 4760 220 4790 220 {}
N 4760 610 4760 580 {}
N 4760 220 4760 210 {}
N 4790 580 4790 390 {}
N 4790 390 4790 220 {}
N 4420 580 4460 580 {}
N 4460 480 4470 480 {}
N 4470 460 4480 460 {}
N 4450 440 4460 440 {}
N 4460 440 4480 440 {}
N 4480 430 4490 430 {}
N 4450 410 4460 410 {}
N 4460 410 4480 410 {}
N 4480 410 4490 410 {}
N 4490 400 4510 400 {}
N 4510 370 4520 370 {}
N 4520 340 4530 340 {}
N 4530 330 4540 330 {}
N 4540 260 4670 260 {}
N 4540 210 4580 210 {}
N 4700 180 4720 180 {}
N 4620 160 4670 160 {}
N 4670 160 4700 160 {}
N 4420 610 4420 580 {}
N 4450 440 4450 410 {}
N 4460 580 4460 480 {}
N 4460 440 4460 410 {}
N 4470 480 4470 460 {}
N 4480 460 4480 440 {}
N 4480 440 4480 430 {}
N 4480 420 4480 410 {}
N 4490 430 4490 410 {}
N 4490 410 4490 400 {}
N 4510 400 4510 370 {}
N 4520 370 4520 340 {}
N 4530 340 4530 330 {}
N 4540 330 4540 260 {}
N 4540 260 4540 210 {}
N 4620 180 4620 160 {}
N 4670 260 4670 160 {}
N 4700 180 4700 160 {}
N 2100 640 2140 640 {}
N 2140 640 2280 640 {}
N 2280 640 2440 640 {}
N 2440 640 2540 640 {}
N 2030 610 2060 610 {}
N 2030 560 2140 560 {}
N 2000 330 2030 330 {}
N 2000 330 2000 310 {}
N 2030 610 2030 560 {}
N 2030 560 2030 330 {}
N 2140 640 2140 560 {}
N 1800 410 1820 410 {}
N 1800 360 1910 360 {}
N 1900 320 1910 320 {}
N 1800 310 1820 310 {}
N 1860 280 1900 280 {}
N 1920 280 1960 280 {}
N 1900 270 1920 270 {}
N 1800 410 1800 360 {}
N 1800 360 1800 310 {}
N 1900 320 1900 280 {}
N 1900 280 1900 270 {}
N 1910 360 1910 320 {}
N 1920 280 1920 270 {}
N 2220 610 2240 610 {}
N 2220 580 2230 580 {}
N 2230 580 2240 580 {}
N 2240 580 2260 580 {}
N 2260 580 2270 580 {}
N 2220 570 2230 570 {}
N 3200 440 3220 440 {}
N 2260 430 3200 430 {}
N 2260 340 2310 340 {}
N 2240 220 2260 220 {}
N 2220 610 2220 580 {}
N 2230 580 2230 570 {}
N 2240 580 2240 570 {}
N 2240 220 2240 190 {}
N 2260 580 2260 430 {}
N 2260 430 2260 340 {}
N 2260 340 2260 220 {}
N 3200 440 3200 430 {}
